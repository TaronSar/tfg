# Repository TaronSar/tfg (continued)

## EAGLE design DAA/DAA/items/hw_DAA/variants/BASIC/design/hw_DAA.brd (continued)

Schematic: hw_DAA.sch, sheet 23, DDR4 Memory ECC Bank

Parts:
C257, C258, C262, C263, C266, C267, C268, C271, C272, C273, C274, C275, C277, C278, C281, C282, C283: 1uF,10%,0402,25V; C0402
C259, C260, C261, C264, C265: 4.7uF,20%,0402,10V; C0402
C269, C270: 2.2uF,10%,0402,16V; C0402
C276, C279, C280, C487, C488, C489, C490, C491: 100nF,10%,0402,50V; C0402
C284: 10nF,10%,0402,50V; C0402
C483, C485: 470nF,10%,0402,16V; C0402
C484, C486: 68nF,10%,0402,50V; C0402
IC18: MT40A1G16TD-062E AAT_F; FBGA96_NSMD_MICRON
R145, R147, R148, R149, R150, R154, R155, R157, R305, R306, R307, R308, R309, R310, R311, R312, R313, R314, R315, R316, R317, R318, R319, R320, R321: 39,1%,0402; R0402
R146, R158, R159, R160: 4.7K,1%,0402; R0402
R151, R152: 240,1%,0402; R0402
R153: 499,1%,0402; R0402
R156, R161: 36,1%,0402; R0402
R162: 49.9,1%,0402; R0402

Connections:
DDR4_A0: IC18.P3 (A0), R321.2; also elsewhere on the board
DDR4_A1: IC18.P7 (A1), R320.2; also elsewhere on the board
DDR4_A2: IC18.R3 (A2), R319.2; also elsewhere on the board
DDR4_A3: IC18.N7 (A3), R318.2; also elsewhere on the board
DDR4_A4: IC18.N3 (A4), R317.2; also elsewhere on the board
DDR4_A5: IC18.P8 (A5), R316.2; also elsewhere on the board
DDR4_A6: IC18.P2 (A6), R315.2; also elsewhere on the board
DDR4_A7: IC18.R8 (A7), R314.2; also elsewhere on the board
DDR4_A8: IC18.R2 (A8), R313.2; also elsewhere on the board
DDR4_A9: IC18.R7 (A9), R312.2; also elsewhere on the board
DDR4_A10_AP: IC18.M3 (A10/AP), R311.2; also elsewhere on the board
DDR4_A11: IC18.T2 (A11), R310.2; also elsewhere on the board
DDR4_A12_BCN: IC18.M7 (A12/BC_N), R309.2; also elsewhere on the board
DDR4_A13: IC18.T8 (A13), R308.2; also elsewhere on the board
DDR4_A14_WEN: IC18.L2 (A14/WE_N), R307.2; also elsewhere on the board
DDR4_A15_CASN: IC18.M8 (A15/CAS_N), R306.2; also elsewhere on the board
DDR4_A16_RASN: IC18.L8 (A16/RAS_N), R305.2; also elsewhere on the board
DDR4_ACT_N: IC18.L3 (ACT_N), R147.2; also elsewhere on the board
DDR4_ALERT_N: IC18.P9 (ALERT_N), R162.2; also elsewhere on the board
DDR4_BA0: IC18.N2 (BA0), R155.2; also elsewhere on the board
DDR4_BA1: IC18.N8 (BA1), R154.2; also elsewhere on the board
DDR4_BG0: IC18.M2 (BG0), R150.2; also elsewhere on the board
DDR4_CK0_N: IC18.K8 (CK_C), R161.2; also elsewhere on the board
DDR4_CK0_P: IC18.K7 (CK_T), R156.2; also elsewhere on the board
DDR4_CKE0: IC18.K2 (CKE), R148.2; also elsewhere on the board
DDR4_CS0_N: IC18.L7 (CS_N), R145.2; also elsewhere on the board
DDR4_DM8: IC18.E7 (LDM_N/LDBI_N); also elsewhere on the board
DDR4_DQ64: IC18.G2 (DQ0); also elsewhere on the board
DDR4_DQ65: IC18.F7 (DQ1); also elsewhere on the board
DDR4_DQ66: IC18.H3 (DQ2); also elsewhere on the board
DDR4_DQ67: IC18.H7 (DQ3); also elsewhere on the board
DDR4_DQ68: IC18.H2 (DQ4); also elsewhere on the board
DDR4_DQ69: IC18.H8 (DQ5); also elsewhere on the board
DDR4_DQ70: IC18.J3 (DQ6); also elsewhere on the board
DDR4_DQ71: IC18.J7 (DQ7); also elsewhere on the board
DDR4_DQS8_N: IC18.F3 (LDQS_C); also elsewhere on the board
DDR4_DQS8_P: IC18.G3 (LDQS_T); also elsewhere on the board
DDR4_ODT0: R149.2; also elsewhere on the board
DDR4_ODT_LDQS: IC18.K3 (ODT), R151.2
DDR4_PAR: IC18.T3 (PAR), R157.2; also elsewhere on the board
DDR4_RESET_N: IC18.P1 (RESET_N), R146.1; also elsewhere on the board
DDR4_TEN_4: IC18.N9 (TEN), R153.1
DDR4_TER_CK: C284.1, R156.1, R161.1
DDR4_UDBI_N: IC18.E2 (UDM_N/UDBI_N), R160.2
DDR4_UDQS_C: IC18.A7 (UDQS_C), R159.2
DDR4_UDQS_T: IC18.B7 (UDQS_T), R158.2
DDR4_ZQ_4: IC18.F9 (ZQ), R152.2
GND: C257.2, C258.2, C259.2, C260.2, C261.2, C262.2, C263.2, C264.2, C265.2, C266.2, C267.2, C268.2, C269.2, C270.2, C271.2, C272.2, C273.2, C274.2, C275.2, C276.2, C277.2, C278.2, C279.2, C280.2, C281.2, C282.2, C283.2, C483.2, C484.2, C485.2, C486.2, C487.2, C488.2, C489.2, C490.2, C491.2, IC18.A2 (VSSQ_1), IC18.A8 (VSSQ_2), IC18.B2 (VSS_1), IC18.C9 (VSSQ_3), IC18.D2 (VSSQ_4), IC18.D8 (VSSQ_5), IC18.E1 (VSS_2), IC18.E3 (VSSQ_6), IC18.E8 (VSSQ_7), IC18.E9 (VSS_3), IC18.F1 (VSSQ_8), IC18.G8 (VSS_4), IC18.H1 (VSSQ_9), IC18.H9 (VSSQ_10), IC18.K1 (VSS_5), IC18.K9 (VSS_6), IC18.M9 (VSS_7), IC18.N1 (VSS_8), IC18.T1 (VSS_9), R146.2, R152.1, R153.2, R159.1; also elsewhere on the board
PSDDR: C259.1, C260.1, C264.1, C265.1, C269.1, C270.1, C274.1, C275.1, C279.1, C280.1, C284.2, C483.1, C484.1, C485.1, C486.1, IC18.A1 (VDDQ_1), IC18.A9 (VDDQ_2), IC18.B3 (VDD_1), IC18.B9 (VDD_2), IC18.C1 (VDDQ_3), IC18.D1 (VDD_3), IC18.D9 (VDDQ_4), IC18.F2 (VDDQ_5), IC18.F8 (VDDQ_6), IC18.G1 (VDDQ_7), IC18.G7 (VDD_6), IC18.G9 (VDDQ_8), IC18.J1 (VDD_4), IC18.J2 (VDDQ_9), IC18.J8 (VDDQ_10), IC18.J9 (VDD_5), IC18.L1 (VDD_10), IC18.L9 (VDD_7), IC18.R1 (VDD_8), IC18.T9 (VDD_9), R151.1, R158.1, R160.1, R162.1; also elsewhere on the board
VPP: C261.1, C266.1, C271.1, C487.1, IC18.B1 (VPP_1), IC18.R9 (VPP_2); also elsewhere on the board
VTT: C257.1, C258.1, C262.1, C263.1, C267.1, C268.1, C272.1, C273.1, C277.1, C278.1, C281.1, C282.1, C283.1, C488.1, C489.1, C490.1, C491.1, R145.1, R147.1, R148.1, R149.1, R150.1, R154.1, R155.1, R157.1, R305.1, R306.1, R307.1, R308.1, R309.1, R310.1, R311.1, R312.1, R313.1, R314.1, R315.1, R316.1, R317.1, R318.1, R319.1, R320.1, R321.1; also elsewhere on the board
VTTREF: C276.1, IC18.M1 (VREFCA); also elsewhere on the board

Notes on the sheet:
1010xx
jcc5
dcs7
0.6V
DDR4 ECC MEMORY
DDR4 MEMORIES TERMINATION RESISTORS
1.2V
2.5V
BASIC/design/hw_DAA.sch
hw_DAA/BASIC

Schematic: hw_DAA.sch, sheet 24, MicroSD Card

Parts:
C285, C289: 1uF,10%,0402,25V; C0402
C286, C287, C290, C291, C292, C294: 100nF,10%,0402,50V; C0402
C288: NOPOP; C0402
C293: 10uF,20%,0603,10V; C0603
CN6: 47219-2001; SD-LATCH
D23: AQ4020-01FTG; SOD-323
IC19: SN74LVC1G04QDCKRQ1; DCK5
IC20: NVT4858HK; XQFN16
IC21, IC22: TPS22910AYZVR; DSBGA-4_YZV
R163, R164, R166, R170, R173, R174, R330, R331, R333, R334, R335, R336, R337: 33,1%,0402; R0402
R165, R167, R171: 10K,1%,0402; R0402
R168, R169, R332: 0,5%,0402; R0402
R172: 4.99K,1%,0402; R0402

Connections:
+1V8: C286.1, C287.1, C289.1, IC19.5 (VCC), IC20.15 (VCCA), IC22.A2 (VIN); also elsewhere on the board
+3V3: C285.1, C293.1, C294.1, CN6.4 (VDD), D23.K, IC21.A2 (VIN); also elsewhere on the board
GND: C285.2, C286.2, C287.2, C288.2, C289.2, C290.2, C291.2, C292.2, C293.2, C294.2, CN6.6 (VSS), CN6.G1 (SHIELD_1), CN6.G2 (SHIELD_2), CN6.G3 (SHIELD_3), CN6.G4 (SHIELD_4), D23.A, IC19.3 (GND), IC20.7 (GND), IC21.B1 (GND), IC22.B1 (GND), R165.1, R167.1; also elsewhere on the board
unnamed: IC19.4 (O), R169.2
unnamed: IC21.B2 (ON), R168.1
unnamed: IC22.B2 (ON), R169.1
SDIO_1_CLK: R331.2; also elsewhere on the board
SDIO_1_CLKFB: R166.2; also elsewhere on the board
SDIO_1_CMD: R163.2; also elsewhere on the board
SDIO_1_DAT0: R174.2; also elsewhere on the board
SDIO_1_DAT1: R330.2; also elsewhere on the board
SDIO_1_DAT2: R164.2; also elsewhere on the board
SDIO_1_DAT3: R173.2; also elsewhere on the board
SDIO_1_SEL: R332.2; also elsewhere on the board
SDIO_A_CLK: IC20.5 (CLKA), R331.1
SDIO_A_CMD: IC20.16 (CMDA), R163.1
SDIO_A_D0: IC20.3 (DAT0A), R174.1
SDIO_A_D1: IC20.4 (DAT1A), R330.1
SDIO_A_D2: IC20.1 (DAT2A), R164.1
SDIO_A_D3: IC20.2 (DAT3A), R173.1
SDIO_B_CLK: IC20.8 (CLKB), R170.2
SDIO_B_CMD: IC20.13 (CMDB), R172.1, R337.2
SDIO_B_D0: IC20.10 (DAT0B), R333.2
SDIO_B_D1: IC20.9 (DAT1B), R334.2
SDIO_B_D2: IC20.12 (DAT2B), R335.2
SDIO_B_D3: IC20.11 (DAT3B), R171.1, R336.2
SDIO_CLK_FB: C288.1, IC20.6 (CLK_FB), R166.1, R167.2
SDIO_SEL: IC19.2 (I), R165.2, R168.2, R332.1
SD_CLK: CN6.5 (CLK/SCLK), R170.1
SD_CMD: CN6.3 (DI/CMD), R337.1
SD_D0: CN6.7 (DO/DAT0), R333.1
SD_D1: CN6.8 (NC/DAT1), R334.1
SD_D2: CN6.1 (NC/DAT2), R335.1
SD_D3: CN6.2 (CS/CD/DAT3), R336.1
SD_VCCB: C290.1, C291.1, C292.1, IC20.14 (VCCB), IC21.A1 (VOUT), IC22.A1 (VOUT), R171.2, R172.2

Notes on the sheet:
1010xx
jcc5
dcs7
MICRO SD 3.0 MEMORY
BASIC/design/hw_DAA.sch
hw_DAA/BASIC

Schematic: hw_DAA.sch, sheet 25, CAN FD

Parts:
C295, C296, C298, C299: 100nF,10%,0402,50V; C0402
C297, C300: 4.7nF,20%,0402,100V; C0402
IC23, IC24: TCAN1462VDRBRQ1; VSON-8
L16, L17: 1812CAN-113NRC; 1812CAN
OP1, OP2, OP3, OP4: TLP3431(TP,F; VSON-4
Q13, Q14: DMN2710UTQ-7; SOT-523
R175, R176, R177, R182, R183, R184: 10K,1%,0402; R0402
R178, R179, R185, R186: 499,1%,0402; R0402
R180, R181, R187, R188: 60.4,1%,0805; R0805

Connections:
+3V3: C295.1, C298.1, IC23.5 (VIO), IC24.5 (VIO), R176.2, R183.2; also elsewhere on the board
+5V: C296.1, C299.1, IC23.3 (VCC), IC24.3 (VCC), R178.2, R179.2, R185.2, R186.2; also elsewhere on the board
CANA_N: IC23.6 (CANL), L16.3
CANA_P: IC23.7 (CANH), L16.2
CANB_N: IC24.6 (CANL), L17.3
CANB_P: IC24.7 (CANH), L17.2
CAN_0_RES: Q13.1 (G), R175.2; also elsewhere on the board
CAN_0_RX: IC23.4 (RXD); also elsewhere on the board
CAN_0_STB: IC23.8 (STB), R177.2; also elsewhere on the board
CAN_0_TX: IC23.1 (TXD), R176.1; also elsewhere on the board
CAN_1_RES: Q14.1 (G), R182.2; also elsewhere on the board
CAN_1_RX: IC24.4 (RXD); also elsewhere on the board
CAN_1_STB: IC24.8 (STB), R184.2; also elsewhere on the board
CAN_1_TX: IC24.1 (TXD), R183.1; also elsewhere on the board
CAN_A_N: L16.4, OP2.3 (D3); also elsewhere on the board
CAN_A_P: L16.1, OP1.4 (D4); also elsewhere on the board
CAN_B_N: L17.4, OP4.3 (D3); also elsewhere on the board
CAN_B_P: L17.1, OP3.4 (D4); also elsewhere on the board
GND: C295.2, C296.2, C297.1, C298.2, C299.2, C300.1, IC23.2 (GND), IC23.9 (GND), IC24.2 (GND), IC24.9 (GND), Q13.2 (S), Q14.2 (S), R175.1, R177.1, R182.1, R184.1; also elsewhere on the board
unnamed: OP2.4 (D4), R181.1
unnamed: OP1.2 (K), OP2.2 (K), Q13.3 (D)
unnamed: OP2.1 (A), R179.1
unnamed: C300.2, R187.1, R188.2
unnamed: OP3.3 (D3), R187.2
unnamed: OP4.4 (D4), R188.1
unnamed: OP4.1 (A), R186.1
unnamed: C297.2, R180.1, R181.2
unnamed: OP1.1 (A), R178.1
unnamed: OP3.1 (A), R185.1
unnamed: OP1.3 (D3), R180.2
unnamed: OP3.2 (K), OP4.2 (K), Q14.3 (D)

Notes on the sheet:
1010xx
jcc5
dcs7
CAN FD A
CAN FD B
BASIC/design/hw_DAA.sch
hw_DAA/BASIC

Schematic: hw_DAA.sch, sheet 26, RS485 - RS232

Parts:
C301, C302, C303, C304, C305, C306: 100nF,10%,0402,50V; C0402
IC25: SN65HVD33MDREP; SOIC14_D_TEX
IC26: SN65C3221IPWRQ1; TSSOP-16(TEXAS)
OP5, OP6: TLP3475(TP,F; VSON-4
Q15, Q16: DMN2710UTQ-7; SOT-523
R189, R190, R191, R192, R193, R205, R206, R207, R208: 10K,1%,0402; R0402
R194, R195: 499,1%,0402; R0402
R196, R197, R198, R199, R200: 10,1%,330mW,0603; R0603
R201, R202: NOPOP; R0402
R203, R204: 120,1%,500mW,0805; R0805

Connections:
!RS232_EN: IC26.1 (!EN), R208.2
!RS232_FOFF: IC26.16 (!FORCEOFF), R206.2
!RS232_INV: IC26.10 (!INVALID), R207.2
!RS485_RE: IC25.3 (!RE), R192.2; also elsewhere on the board
+3V3: C301.1, C302.1, IC25.13 (VCC_1), IC25.14 (VCC_2), IC26.15 (VCC), R191.2, R205.1, R206.1; also elsewhere on the board
+5V: R194.1, R195.1; also elsewhere on the board
GND: C301.2, C302.2, C303.2, C304.1, IC25.6 (GND_1), IC25.7 (GND_2), IC26.14 (GND), Q15.2 (S), Q16.2 (S), R189.1, R190.1, R192.1, R193.1, R200.2, R207.1, R208.1; also elsewhere on the board
GND_485: R200.1; also elsewhere on the board
unnamed: C305.1, IC26.2 (C1+)
unnamed: C305.2, IC26.4 (C1-)
unnamed: C306.2, IC26.5 (C2+)
unnamed: C306.1, IC26.6 (C2-)
unnamed: OP6.1 (A), R195.2
unnamed: C303.1, IC26.3 (V+)
unnamed: C304.2, IC26.7 (V-)
unnamed: OP5.1 (A), R194.2
unnamed: OP5.4 (D4), R201.2, R203.1
unnamed: OP5.2 (K), Q15.3 (D)
unnamed: OP6.2 (K), Q16.3 (D)
unnamed: OP6.3 (D3), R202.1, R204.1
RS232_FON: IC26.12 (FORCEON), R205.2
RS232_RX: IC26.8 (RIN); also elsewhere on the board
RS232_TX: IC26.13 (DOUT); also elsewhere on the board
RS485_DE: IC25.4 (DE), R193.2; also elsewhere on the board
RS485_RES_RX: Q16.1 (G), R190.2; also elsewhere on the board
RS485_RES_TX: Q15.1 (G), R189.2; also elsewhere on the board
RS485_RXD_N: IC25.11 (B), R199.2
RS485_RXD_P: IC25.12 (A), R198.2
RS485_RX_N: OP6.4 (D4), R199.1, R202.2; also elsewhere on the board
RS485_RX_P: R198.1, R204.2; also elsewhere on the board
RS485_TXD_N: IC25.10 (Z), R197.2
RS485_TXD_P: IC25.9 (Y), R196.2
RS485_TX_N: OP5.3 (D3), R197.1, R201.1; also elsewhere on the board
RS485_TX_P: R196.1, R203.2; also elsewhere on the board
UART_0_RX: IC25.2 (R), R191.1; also elsewhere on the board
UART_0_TX: IC25.5 (D); also elsewhere on the board
UART_1_RX: IC26.9 (ROUT); also elsewhere on the board
UART_1_TX: IC26.11 (DIN); also elsewhere on the board

Notes on the sheet:
1010xx
jcc5
dcs7
RS-485 FULL DUPLEX
RS-232
BASIC/design/hw_DAA.sch
hw_DAA/BASIC

Schematic: hw_DAA.sch, sheet 27, Ethernet

Parts:
C307, C325, C328, C335, C341: 10nF,10%,0402,50V; C0402
C308, C309, C310, C311, C312, C313, C315, C316, C319, C320, C330, C331, C333, C334, C337, C340: 100nF,10%,0402,50V; C0402
C314, C317, C318, C321, C322, C323, C324, C326, C329, C336, C339: 1uF,10%,0402,25V; C0402
C327, C332, C338, C342: 10uF,20%,0603,10V; C0603
C343: 1nF,10%,1206,2KV; C1206
D24, D25: HSP051-4M10; USON-10
IC27: DP83867ERGZT; VQFN-48
R209, R322, R323, R324, R325, R326, R327, R328, R329: 0,5%,0402; R0402
R210, R212, R215, R235: 2.49K,1%,0402; R0402
R211, R213, R226, R227, R228, R229, R230, R231, R232, R233: NOPOP; R0402
R214: 5.76K,1%,0402; R0402
R216, R217: 2.2K,1%,0402; R0402
R218: 11K,1%,0402; R0402
R219: 1.5K,1%,0402; R0402
R220: 1K,1%,0402; R0402
R221, R223, R224, R225: 75,1%,0402; R0402
R222, R338: 0,1%,0805; R0805
R234: 10K,1%,0402; R0402
T1: HX5008NL
Y4: ECS-2520MVQ-250-CN-TR; ECS-2520MVQ

Connections:
+1V: C310.1, C313.1, C316.1, C319.1, C322.1, C324.1, C326.1, C329.1, C335.1, C338.1, IC27.6 (VDD1P0_1), IC27.24 (VDD1P0_2), IC27.31 (VDD1P0_3), IC27.42 (VDD1P0_4); also elsewhere on the board
+1V8: C309.1, C312.1, C315.1, C318.1, C320.1, C321.1, C323.1, C328.1, C330.1, C332.1, C333.1, C336.1, C339.1, C341.1, C342.1, IC27.13 (VDDA1P8_1), IC27.19 (VDDIO_1), IC27.30 (VDDIO_2), IC27.41 (VDDIO_3), IC27.48 (VDDA1P8_2), R210.2, R212.2, R214.2, R216.2, R217.2, R219.2, R220.2, R226.2, R228.2, R230.2, R232.2, R234.2, Y4.4 (VCC); also elsewhere on the board
+2V5: C308.1, C311.1, C314.1, C317.1, C325.1, C327.1, IC27.3 (VDDA2P5_1), IC27.9 (VDDA2P5_2); also elsewhere on the board
CHASSIS: R222.1, R338.1; also elsewhere on the board
ETH_25MHZ_EN: R220.1, Y4.1 (TR-ST)
ETH_A_N: R323.1; also elsewhere on the board
ETH_A_P: R322.1; also elsewhere on the board
ETH_B_N: R325.1; also elsewhere on the board
ETH_B_P: R324.1; also elsewhere on the board
ETH_CHASSIS: C343.2, R222.2, R338.2; also elsewhere on the board
ETH_CHS: C343.1, R221.1, R223.1, R224.1, R225.1
ETH_CLKO: R209.1; also elsewhere on the board
ETH_CLK_OUT: IC27.18 (CLK_OUT), R209.2
ETH_C_N: R327.1; also elsewhere on the board
ETH_C_P: R326.1; also elsewhere on the board
ETH_D_N: R329.1; also elsewhere on the board
ETH_D_P: R328.1; also elsewhere on the board
ETH_GPIO0: IC27.39 (GPIO_0), R226.1, R227.2; also elsewhere on the board
ETH_GPIO1: IC27.40 (GPIO_1), R228.1, R229.2; also elsewhere on the board
ETH_GTX_CLK: IC27.29 (GTX_CLK); also elsewhere on the board
ETH_INT_PWDN: IC27.44 (INT/PWDN), R217.1; also elsewhere on the board
ETH_LED0: IC27.47 (LED_0), R230.1, R231.2
ETH_LED1: IC27.46 (LED_1), R232.1, R233.2
ETH_LED2: IC27.45 (LED_2), R234.1, R235.2
ETH_MDC: IC27.16 (MDC); also elsewhere on the board
ETH_MDIO: IC27.17 (MDIO), R219.1; also elsewhere on the board
ETH_RBIAS: IC27.12 (RBIAS), R218.1
ETH_RSTN: C307.1, IC27.43 (RESET_N), R216.1; also elsewhere on the board
ETH_RX_CLK: IC27.32 (RX_CLK); also elsewhere on the board
ETH_RX_CTRL: IC27.38 (RX_CTRL), R214.1, R215.2; also elsewhere on the board
ETH_RX_D0: IC27.33 (RX_D0/SGMII_COP), R212.1, R213.2; also elsewhere on the board
ETH_RX_D1: IC27.34 (RX_D1/SGMII_CON); also elsewhere on the board
ETH_RX_D2: IC27.35 (RX_D2/SGMII_SOP), R210.1, R211.2; also elsewhere on the board
ETH_RX_D3: IC27.36 (RX_D3/SGMII_SON); also elsewhere on the board
ETH_TX_CTRL: IC27.37 (TX_CTRL); also elsewhere on the board
ETH_TX_D0: IC27.28 (TX_D0/SGMII_SIN); also elsewhere on the board
ETH_TX_D1: IC27.27 (TX_D1/SGMII_SIP); also elsewhere on the board
ETH_TX_D2: IC27.26 (TX_D2); also elsewhere on the board
ETH_TX_D3: IC27.25 (TX_D3); also elsewhere on the board
ETH_XI: IC27.15 (XI), Y4.3 (OUT)
GND: C307.2, C308.2, C309.2, C310.2, C311.2, C312.2, C313.2, C314.2, C315.2, C316.2, C317.2, C318.2, C319.2, C320.2, C321.2, C322.2, C323.2, C324.2, C325.2, C326.2, C327.2, C328.2, C329.2, C330.2, C331.2, C332.2, C333.2, C334.2, C335.2, C336.2, C337.2, C338.2, C339.2, C340.2, C341.2, C342.2, D24.3 (5), D24.8 (5), D24.38 (5), D25.3 (5), D25.8 (5), D25.38 (5), IC27.49 (GND), R211.1, R213.1, R215.1, R218.2, R227.1, R229.1, R231.1, R233.1, R235.1, Y4.2 (GND); also elsewhere on the board
MCT_A: R225.2, T1.24 (MCT1)
MCT_B: R224.2, T1.21 (MCT2)
MCT_C: R223.2, T1.18 (MCT3)
MCT_D: R221.2, T1.15 (MCT4)
MX_A_N: R323.2, T1.22 (MX1-)
MX_A_P: R322.2, T1.23 (MX1+)
MX_B_N: R325.2, T1.19 (MX2-)
MX_B_P: R324.2, T1.20 (MX2+)
MX_C_N: R327.2, T1.16 (MX3-)
MX_C_P: R326.2, T1.17 (MX3+)
MX_D_N: R329.2, T1.13 (MX4-)
MX_D_P: R328.2, T1.14 (MX4+)
TCT_A: C331.1, T1.1 (TCT1)
TCT_B: C334.1, T1.4 (TCT2)
TCT_C: C337.1, T1.7 (TCT3)
TCT_D: C340.1, T1.10 (TCT4)
TD_A_N: D24.2, D24.9 (2), IC27.2 (TD_M_A), T1.3 (TD1-)
TD_A_P: D24.1, D24.10 (1), IC27.1 (TD_P_A), T1.2 (TD1+)
TD_B_N: D24.5 (4), D24.6 (4), IC27.5 (TD_M_B), T1.6 (TD2-)
TD_B_P: D24.4 (3), D24.7 (3), IC27.4 (TD_P_B), T1.5 (TD2+)
TD_C_N: D25.2, D25.9 (2), IC27.8 (TD_M_C), T1.9 (TD3-)
TD_C_P: D25.1, D25.10 (1), IC27.7 (TD_P_C), T1.8 (TD3+)
TD_D_N: D25.5 (4), D25.6 (4), IC27.11 (TD_M_D), T1.12 (TD4-)
TD_D_P: D25.4 (3), D25.7 (3), IC27.10 (TD_P_D), T1.11 (TD4+)

Notes on the sheet:
Ethernet Interface
25MHz
1010xx
jcc5
dcs7
Ethernet LEDs and GPIO
Matching impedance resistors Close to connector
BASIC/design/hw_DAA.sch
hw_DAA/BASIC

Schematic: hw_DAA.sch, sheet 28, Image Sensor

Parts:
C344, C348, C386: 22uF,10%,1206,16V; C1206
C345, C352, C369, C371, C378: 10uF,20%,0603,10V; C0603
C346, C347, C353, C354, C363, C370, C376, C389, C391, C397, C400, C406, C407, C409, C410: 4.7uF,20%,0402,10V; C0402
C349, C350, C351, C355, C356, C357, C358, C359, C360, C364, C365, C366, C367, C372, C373, C374, C375, C377, C380, C381, C382, C384, C385, C387, C388, C390, C392, C393, C394, C395, C396, C398, C399, C401, C402, C404: 100nF,10%,0402,50V; C0402
C361, C362, C368, C379, C383: 1uF,10%,0402,25V; C0402
C403: NOPOP; C0402
C405: 820pF,10%,0402,50V; C0402
C408: 220nF,10%,0402,35V; C0402
IC28: IMX296LQR-C; LGA-138_NSMD
R236, R240, R241, R243, R244: 10K,1%,0402; R0402
R237: NOPOP; R0402
R238, R239: 4.7K,1%,0402; R0402
R242: 0,5%,0402; R0402
R265: 2K,1%,0402; R0402
R266: 100K,1%,0402; R0402
Y5: SiT8008BI-22-18E-37.125000G; 3.2X2.5

Connections:
!IMX_RSTOUT: R242.2, R265.2, R266.1; also elsewhere on the board
AVDD: C344.1, C345.1, C348.1, C349.1, C352.1, C355.1, C356.1, C359.1, C360.1, C361.1, C364.1, C365.1, C368.1, C371.1, C372.1, C374.1, C376.1, C378.1, C380.1, C382.1, C383.1, C386.1, C387.1, C391.1, C393.1, C395.1, C396.1, C398.1, C401.1, IC28.A4 (VDDHAN), IC28.A6 (VDDHRST), IC28.A7 (VDDHOFG), IC28.A10 (VDDHSEL), IC28.A11 (VDDHTM), IC28.B7 (VDDHTRX), IC28.B10 (VDDHTRG), IC28.E4 (VDDHPX_1), IC28.E6 (VDDHCM_1), IC28.E7 (VDDSUB), IC28.E9 (VDDHCM_2), IC28.E10 (VDDHPX_2), IC28.F4 (VDDHCP), IC28.J4 (VDDHPX_3), IC28.J6 (VDDHCM_3), IC28.J9 (VDDHCM_4), IC28.J10 (VDDHPX_4); also elsewhere on the board
DVDD: C347.1, C351.1, C354.1, C358.1, C363.1, C367.1, C369.1, C370.1, C373.1, C375.1, C377.1, C379.1, C381.1, C384.1, C385.1, C388.1, C389.1, C390.1, C392.1, C394.1, C397.1, C399.1, C400.1, C402.1, IC28.A5 (PVLM), IC28.C1 (VDDLCN_1), IC28.C13 (VDDLCN_2), IC28.D1 (VDDLSC_1), IC28.D13 (VDDLSC_2), IC28.E5 (VDDLCB_1), IC28.E8 (VDDLCB_2), IC28.G13 (VDDLCN_3), IC28.H13 (VDDLSC_3), IC28.J5 (VDDLCB_3), IC28.J8 (VDDLCB_4), IC28.K1 (VDDLSC_4), IC28.K11 (VDDLIO), IC28.L1 (VDDLCN_4), IC28.L8 (VDDLPA); also elsewhere on the board
GND: C344.2, C345.2, C346.2, C347.2, C348.2, C349.2, C350.2, C351.2, C352.2, C353.2, C354.2, C355.2, C356.2, C357.2, C358.2, C359.2, C360.2, C361.2, C362.2, C363.2, C364.2, C365.2, C366.2, C367.2, C368.2, C369.2, C370.2, C371.2, C372.2, C373.2, C374.2, C375.2, C376.2, C377.2, C378.2, C379.2, C380.2, C381.2, C382.2, C383.2, C384.2, C385.2, C386.2, C387.2, C388.2, C389.2, C390.2, C391.2, C392.2, C393.2, C394.2, C395.2, C396.2, C397.2, C398.2, C399.2, C400.2, C401.2, C402.2, C403.2, C404.2, C405.2, C406.2, C407.2, C408.2, C409.2, C410.2, IC28.A1 (NC_1), IC28.A13 (NC_3), IC28.B3 (VSSHAN_1), IC28.B4 (VSSHAN_2), IC28.B5 (VSSHPX_1), IC28.B6 (VRLRST), IC28.B11 (VSSHTM), IC28.C2 (VSSLCN_1), IC28.C7 (VSSHPX_2), IC28.C10 (VRLGND), IC28.C11 (VRLWSS), IC28.C12 (VSSLCN_2), IC28.D2 (VSSLSC_1), IC28.D3 (VSSLSC_2), IC28.D4 (VSSHPX_3), IC28.D5 (VSSHCM_1), IC28.D6 (VSSHCM_2), IC28.D7 (VSSHPX_4), IC28.D8 (VSSHCM_3), IC28.D9 (VSSHCM_4), IC28.D10 (VSSHPX_5), IC28.D11 (VSSHPX_6), IC28.D12 (VSSLSC_3), IC28.E12 (VSSH_1), IC28.E13 (VSSH_2), IC28.F12 (VSSLSC_4), IC28.G4 (VSSHCP), IC28.G12 (VSSLCN_3), IC28.H12 (VSSLSC_5), IC28.J12 (VSSLSC_6), IC28.K2 (VSSLSC_7), IC28.K4 (VSSHPX_7), IC28.K5 (VSSHCM_5), IC28.K6 (VSSHCM_6), IC28.K8 (VSSHCM_7), IC28.K9 (VSSHCM_8), IC28.K10 (VSSHPX_8), IC28.L2 (VSSLCN_4), IC28.L3 (VSSMIF_1), IC28.L5 (VSSMIF_2), IC28.L7 (VSSLPA), IC28.L9 (VSSMIF_3), IC28.L10 (VSSMIF_4), IC28.L11 (VSSLSC_8), IC28.N1 (NC_30), IC28.N13 (NC_40), R237.2, R241.2, R266.2, Y5.2 (GND); also elsewhere on the board
IMX_DMCK_N: IC28.K12 (DMCKM); also elsewhere on the board
IMX_DMCK_P: IC28.K13 (DMCKP); also elsewhere on the board
IMX_DMO_N: IC28.L12 (DMOM); also elsewhere on the board
IMX_DMO_P: IC28.L13 (DMOP); also elsewhere on the board
IMX_EN_CLK: C405.1, R265.1, Y5.1 (EOH)
IMX_INCK: IC28.J13 (INCK), Y5.3 (OUT)
IMX_SCL: IC28.J3 (SCK/SCL), R238.2; also elsewhere on the board
IMX_SDA: IC28.K3 (SDI/SDA), R239.2; also elsewhere on the board
IMX_VBGR: C408.1, IC28.C3 (VBGR)
IMX_VCP_1: C409.1, C410.1, IC28.A8 (VRLOFG), IC28.A9 (VRLSEL), IC28.B8 (VRLTRX), IC28.C8 (VCP_1)
IMX_VCP_2: C406.1, C407.1, IC28.B9 (VRLTRG), IC28.C9 (VCP_2)
IMX_XCLR: C403.1, IC28.G1 (XCLR), R242.1; also elsewhere on the board
IMX_XHS: IC28.H2 (XHS), R244.2; also elsewhere on the board
IMX_XMASTER: IC28.G2 (XMASTER), R236.2, R237.1
IMX_XTRIG: IC28.J2 (XTRIG); also elsewhere on the board
IMX_XVS: IC28.J1 (XVS), R243.2; also elsewhere on the board
unnamed: IC28.G3 (SLAMODE), R241.1
OVDD: C346.1, C350.1, C353.1, C357.1, C362.1, C366.1, C404.1, IC28.F13 (VDDMIO), IC28.L4 (VDDMIF_1), IC28.L6 (VDDMIF_2), R236.1, R238.1, R239.1, R240.1, R243.1, R244.1, Y5.4 (VCC); also elsewhere on the board
SPI_0_SS: IC28.H1 (XCE), R240.2

Notes on the sheet:
37.125MHz
1010xx
jcc5
dcs7
3.3V
1.8V
1.2V
Address: 0x24
IMAGE SENSOR IMX296
Power-On Sequence: DVDD (1.2V) --> 10ms --> OVDD (1.8V) --> 10ms --> AVDD (3.3V) --> 1us --> XCLR --> 2us --> INCK
BASIC/design/hw_DAA.sch
hw_DAA/BASIC

Schematic: hw_DAA.sch, sheet 29, Sensor Multiplexion

Parts:
C494, C495: NOPOP; C0402
CN7: NOPOP; SFW15S-2STE1LF
D27: HSP051-4M10; USON-10
D28: RCLAMP3324PQTCT; USON-10
R69, R70, R245, R246, R247, R248, R251, R252, R253, R254, R339, R340, R341, R342, R343, R344, R345: 0,5%,0402; R0402
R249, R250, R255, R256, R257, R258, R259, R260, R261, R262, R263, R264, R346, R347, R348, R349, R350, R351, R352, R353: NOPOP; R0402

Connections:
AUX_3V3: C494.1, C495.1, CN7.15, D28.5 (4), D28.6 (4), R351.1
AUX_GPIO: CN7.11, D28.1, D28.10 (1), R350.1
AUX_MIPI_CLK_N: CN7.8, D27.5 (4), D27.6 (4), R348.1
AUX_MIPI_CLK_P: CN7.9, D27.4 (3), D27.7 (3), R349.1
AUX_MIPI_D0_N: CN7.2, D27.2, D27.9 (2), R346.1
AUX_MIPI_D0_P: CN7.3, D27.1, D27.10 (1), R347.1
AUX_SCL: CN7.13, D28.2, D28.9 (2), R249.1, R352.1
AUX_SDA: CN7.14, D28.4 (3), D28.7 (3), R250.1, R353.1
AVDD: R351.2; also elsewhere on the board
CM_SCL: R69.1, R249.2, R259.1, R343.2; also elsewhere on the board
CM_SDA: R70.1, R250.2, R260.1, R344.2; also elsewhere on the board
CM_XCLR: R254.1, R264.1, R345.2, R350.2
GND: C494.2, C495.2, CN7.1, CN7.4, CN7.7, CN7.10, D27.3 (5), D27.8 (5), D27.38 (5), D28.3 (5), D28.8 (5), D28.38 (5); also elsewhere on the board
I2C_2_SCL: R69.2; also elsewhere on the board
I2C_2_SDA: R70.2; also elsewhere on the board
IMX_DMCK_N: R340.1; also elsewhere on the board
IMX_DMCK_P: R339.1; also elsewhere on the board
IMX_DMO_N: R342.1; also elsewhere on the board
IMX_DMO_P: R341.1; also elsewhere on the board
IMX_SCL: R343.1; also elsewhere on the board
IMX_SDA: R344.1; also elsewhere on the board
IMX_XCLR: R345.1; also elsewhere on the board
IMX_XHS: R252.1, R262.1; also elsewhere on the board
IMX_XTRIG: R253.1, R263.1; also elsewhere on the board
IMX_XVS: R251.1, R261.1; also elsewhere on the board
MIPI_CM_CLK_N: R246.1, R256.1, R340.2, R348.2
MIPI_CM_CLK_P: R245.1, R255.1, R339.2, R349.2
MIPI_CM_D0_N: R248.1, R258.1, R342.2, R346.2
MIPI_CM_D0_P: R247.1, R257.1, R341.2, R347.2
MIPI_S_CLK_N: R246.2; also elsewhere on the board
MIPI_S_CLK_P: R245.2; also elsewhere on the board
MIPI_S_D0_N: R248.2; also elsewhere on the board
MIPI_S_D0_P: R247.2; also elsewhere on the board
OVDD: R352.2, R353.2; also elsewhere on the board
SER_CLK_N: R256.2; also elsewhere on the board
SER_CLK_P: R255.2; also elsewhere on the board
SER_D0_N: R258.2; also elsewhere on the board
SER_D0_P: R257.2; also elsewhere on the board
SER_GPIO0: R261.2; also elsewhere on the board
SER_GPIO1: R262.2; also elsewhere on the board
SER_GPIO2: R263.2; also elsewhere on the board
SER_GPIO3: R264.2; also elsewhere on the board
SER_SCL: R259.2; also elsewhere on the board
SER_SDA: R260.2; also elsewhere on the board
XCLR: R254.2; also elsewhere on the board
XHS: R252.2; also elsewhere on the board
XTRIG: R253.2; also elsewhere on the board
XVS: R251.2; also elsewhere on the board

Notes on the sheet:
1010xx
jcc5
dcs7
TO SERIALIZER
FROM AUX SENSOR
FROM IMX SENSOR
TO FPGA
If POP use SFW15S-2STE1LF
COMMON LINES
BASIC/design/hw_DAA.sch
hw_DAA/BASIC

Schematic: hw_DAA.sch, sheet 30, IMU

Parts:
C411, C412: 100nF,10%,0402,50V; C0402
IC29: BMI088
R267, R269, R271: 0,5%,0402; R0402
R268, R270, R298, R299: NOPOP; R0402

Connections:
ACEL_INT1: R299.1; also elsewhere on the board
ACEL_INT2: R269.1; also elsewhere on the board
AVDD: C411.1, IC29.3 (VDD); also elsewhere on the board
BMI_INT1: IC29.16 (INT1), R267.2, R299.2
BMI_INT2: IC29.1 (INT2), R268.2, R269.2
BMI_INT3: IC29.12 (INT3), R267.1, R298.2
BMI_INT4: IC29.13 (INT4), R270.2, R271.2
GND: C411.2, C412.2, IC29.2 (NC), IC29.4 (GNDA), IC29.6 (GNDIO); also elsewhere on the board
GYRO_INT1: R298.1; also elsewhere on the board
GYRO_INT2: R271.1; also elsewhere on the board
IMX_SCL: IC29.8 (SCL/SCK); also elsewhere on the board
IMX_SDA: IC29.9 (SDA/SDI); also elsewhere on the board
IMX_XTRIG: R270.1; also elsewhere on the board
OVDD: C412.1, IC29.7 (PS), IC29.10 (SDO2), IC29.11 (VDDIO), IC29.14 (CSB1), IC29.15 (SDO1); also elsewhere on the board
SER_GPIO1: R268.1; also elsewhere on the board

Notes on the sheet:
1010xx
jcc5
dcs7
IMAGE SENSOR IMU
1.8V
3.3V
I2C Addresses * Accelerometer: 0x19 * Gyroscope: 0x69
BASIC/design/hw_DAA.sch
hw_DAA/BASIC

Schematic: hw_DAA.sch, sheet 31, FPD-Link III Serializer

Parts:
C413, C421, C425, C428, C429, C430: 10nF,10%,0402,50V; C0402
C414: 22nF,10%,0402,50V; C0402
C415, C422, C424, C426: 100nF,10%,0402,50V; C0402
C416: NOPOP; C0402
C417: 2.2uF,10%,0402,16V; C0402
C418, C420, C423, C427: 10uF,20%,0603,10V; C0603
C419: 15nF,10%,0402,50V; C0402
C431, C432, C433: 1uF,10%,0402,25V; C0402
FB8, FB9, FB10: BLM18AG102BH1D; L0603
IC30: NOPOP; VQFN-32
R272, R275, R356, R357: NOPOP; R0402
R273: 40.2K,1%,0402; R0402
R274, R276: 10K,1%,0402; R0402
R277: 49.9,1%,0402; R0402

Connections:
COAX_POC: C416.2; also elsewhere on the board
COAX_SER: C416.1, IC30.14 (DOUT+)
GND: C413.1, C415.1, C417.2, C418.1, C420.2, C421.1, C422.1, C423.1, C424.1, C425.1, C426.1, C427.1, C428.2, C429.2, C430.2, C431.2, C432.2, C433.2, IC30.7 (RES0), IC30.33 (GND), R273.1, R276.1, R277.1; also elsewhere on the board
LPF1: C414.1, IC30.9 (LPF1)
LPF2: C424.2, IC30.12 (LPF2)
unnamed: C419.2, IC30.13 (DOUT-)
unnamed: C419.1, R277.2
OVDD: FB8.2, FB9.2, FB10.2, R272.2, R274.2, R275.2, R356.2, R357.2; also elsewhere on the board
SER_CLK_N: IC30.6 (CSI_CLKN); also elsewhere on the board
SER_CLK_P: IC30.5 (CSI_CLKP); also elsewhere on the board
SER_D0_N: IC30.4 (CSI_D0N); also elsewhere on the board
SER_D0_P: IC30.3 (CSI_D0P); also elsewhere on the board
SER_GPIO0: IC30.17 (GPIO_0); also elsewhere on the board
SER_GPIO1: IC30.18 (GPIO_1); also elsewhere on the board
SER_GPIO2: IC30.27 (GPIO_2); also elsewhere on the board
SER_GPIO3: IC30.28 (GPIO_3); also elsewhere on the board
SER_IDX: IC30.19 (CLK_OUT/IDX), R272.1, R273.2
SER_MODE: IC30.21 (MODE), R275.1, R276.2
SER_PDB: C417.1, C420.1, IC30.8 (PDB), R274.1; also elsewhere on the board
SER_SCL: IC30.24 (I2C_SCL), R357.1; also elsewhere on the board
SER_SDA: IC30.23 (I2C_SDA), R356.1; also elsewhere on the board
SER_VDDD: C428.1, C431.1, FB8.1, IC30.25 (VDDD)
SER_VDDDRV: C429.1, C432.1, FB9.1, IC30.16 (VDDDRV)
SER_VDDDRV_CAP: C421.2, C422.2, C423.2, IC30.15 (VDDDRV_CAP)
SER_VDDPLL: C414.2, C430.1, C433.1, FB10.1, IC30.11 (VDDPLL)
SER_VDDPLL_CAP: C425.2, C426.2, C427.2, IC30.10 (VDDPLL_CAP)
SER_VDD_CAP: C413.2, C415.2, C418.2, IC30.26 (VDDD_CAP)

Notes on the sheet:
Address: 0x18
FPD-LINK III SERIALIZER
1010xx
jcc5
dcs7
1kOhm
1.8V
(If POP use DS90UB953TRHBTQ1)
(If POP use 33nF,10%,0402,50V)
BASIC/design/hw_DAA.sch
hw_DAA/BASIC

Schematic: hw_DAA.sch, sheet 32, FPD-Link III Deserializer

Parts:
C434, C435, C437, C443, C445: 100nF,10%,0402,50V; C0402
C436, C439, C444, C446: 4.7uF,20%,0402,10V; C0402
C438: 33nF,10%,0402,50V; C0402
C440: 2.2uF,10%,0402,16V; C0402
C441: 15nF,10%,0402,50V; C0402
C442: 10uF,20%,0603,10V; C0603
C447, C448, C449, C450, C451, C452, C454: 10nF,10%,0402,50V; C0402
C453, C455, C456, C457, C458, C459, C460: 1uF,10%,0402,25V; C0402
FB11, FB12, FB13, FB14: BLM18AG102BH1D; L0603
IC31: DS90UB954TRGZTQ1; VQFN-48
R278: 1K,1%,0402; R0402
R279, R284, R288, R289: 10K,1%,0402; R0402
R280, R281: 4.7K,1%,0402; R0402
R282, R287: NOPOP; R0402
R283, R286: 97.6K,1%,0402; R0402
R285: 78.7K,1%,0402; R0402
R290: 49.9,1%,0402; R0402
Y6: ECS-2520MVQ-250-CN-TR; ECS-2520MVQ

Connections:
COAX_DES: C438.1, IC31.41 (RIN0+)
COAX_POC: C438.2; also elsewhere on the board
DES_GPIO0: IC31.28 (GPIO_0); also elsewhere on the board
DES_GPIO1: IC31.27 (GPIO_1); also elsewhere on the board
DES_GPIO2: IC31.26 (GPIO_2); also elsewhere on the board
DES_GPIO3: IC31.25 (GPIO_3/INTB), R279.1; also elsewhere on the board
DES_IDX: IC31.35 (IDX), R287.1, R288.2
DES_LOCK: IC31.48 (LOCK); also elsewhere on the board
DES_MODE: IC31.37 (MODE), R285.1, R286.2
DES_PASS: IC31.47 (PASS); also elsewhere on the board
DES_PDB: C440.1, C442.1, IC31.30 (PDB), R284.1; also elsewhere on the board
DES_VDD11_CSI: C435.2, C436.2, IC31.20 (VDD11_CSI)
DES_VDD11_D: C445.2, C446.2, IC31.3 (VDD11_D)
DES_VDD11_FPD0: C437.2, C439.2, IC31.43 (VDD11_FPD0)
DES_VDD11_FPD1: C443.2, C444.2, IC31.34 (VDD11_FPD1)
DES_VDD18_CSI: C454.1, C458.1, FB12.1, IC31.17 (VDD18_CSI)
DES_VDD18_FPD: C449.1, C452.1, C456.1, C460.1, FB14.1, IC31.31 (VDD18_FPD1), IC31.40 (VDD18_FPD0)
DES_VDD18_P: C448.1, C451.1, C455.1, C459.1, FB13.1, IC31.36 (VDD18_P1), IC31.45 (VDD18_P0)
DES_VDDIO: C447.1, C450.1, C453.1, C457.1, FB11.1, IC31.7 (VDDIO_1), IC31.29 (VDDIO_2)
DES_VDD_SEL: IC31.46 (VDD_SEL), R289.2
DES_XIN: IC31.5 (XIN/REFCLK), Y6.3 (OUT)
FPD_I_25MHZ_EN: R278.1, Y6.1 (TR-ST)
FPD_I_BISTEN: IC31.6 (BISTEN), R282.1, R283.2
GND: C434.2, C435.1, C436.1, C437.1, C439.1, C440.2, C442.2, C443.1, C444.1, C445.1, C446.1, C447.2, C448.2, C449.2, C450.2, C451.2, C452.2, C453.2, C454.2, C455.2, C456.2, C457.2, C458.2, C459.2, C460.2, IC31.44 (RES), IC31.49 (GND), R283.1, R286.1, R288.1, R289.1, R290.1, Y6.2 (GND); also elsewhere on the board
I2C_3_SCL: IC31.2 (I2C_SCL), R280.1; also elsewhere on the board
I2C_3_SDA: IC31.1 (I2C_SDA), R281.1; also elsewhere on the board
MIPI_I_CLK_N: IC31.11 (CSI_CLK0N); also elsewhere on the board
MIPI_I_CLK_P: IC31.12 (CSI_CLK0P); also elsewhere on the board
MIPI_I_D0_N: IC31.13 (CSI_D0N); also elsewhere on the board
MIPI_I_D0_P: IC31.14 (CSI_D0P); also elsewhere on the board
MIPI_I_D1_N: IC31.15 (CSI_D1N); also elsewhere on the board
MIPI_I_D1_P: IC31.16 (CSI_D1P); also elsewhere on the board
unnamed: C441.2, IC31.42 (RIN0-)
unnamed: C441.1, R290.2
OVDD: C434.1, FB11.2, FB12.2, FB13.2, FB14.2, R278.2, R279.2, R280.2, R281.2, R282.2, R284.2, R285.2, R287.2, Y6.4 (VCC); also elsewhere on the board

Notes on the sheet:
25MHz
1010xx
jcc5
dcs7
Address: 0x30
FPD-LINK III DESERIALIZER
1kOhm
1.8V
BASIC/design/hw_DAA.sch
hw_DAA/BASIC

Schematic: hw_DAA.sch, sheet 33, GPIO Level Shifter

Parts:
C461, C462: 100nF,10%,0402,50V; C0402
IC32: TXB0106IPWRQ1; TSSOP-16(TEXAS)
R291: 10K,1%,0402; R0402
R292, R293, R294, R295, R296, R297: 0,5%,0402; R0402

Connections:
+1V8: C461.1, IC32.2 (VCCA); also elsewhere on the board
+5V: C462.1, IC32.15 (VCCB); also elsewhere on the board
GND: C461.2, C462.2, IC32.9 (GND), R291.1; also elsewhere on the board
GPIO_1: R292.1; also elsewhere on the board
GPIO_1_1V8: IC32.1 (A1); also elsewhere on the board
GPIO_2: R293.1; also elsewhere on the board
GPIO_2_1V8: IC32.3 (A2); also elsewhere on the board
GPIO_3: R294.1; also elsewhere on the board
GPIO_3_1V8: IC32.4 (A3); also elsewhere on the board
GPIO_4: R295.1; also elsewhere on the board
GPIO_4_1V8: IC32.5 (A4); also elsewhere on the board
GPIO_5: R296.1; also elsewhere on the board
GPIO_5_1V8: IC32.6 (A5); also elsewhere on the board
GPIO_6: R297.1; also elsewhere on the board
GPIO_6_1V8: IC32.7 (A6); also elsewhere on the board
GPIO_OE: IC32.8 (OE), R291.2; also elsewhere on the board
unnamed: IC32.16 (B1), R292.2
unnamed: IC32.10 (B6), R297.2
unnamed: IC32.11 (B5), R296.2
unnamed: IC32.12 (B4), R295.2
unnamed: IC32.13 (B3), R294.2
unnamed: IC32.14 (B2), R293.2

Notes on the sheet:
1010xx
jcc5
dcs7
GPIO LEVEL SHIFTER
BASIC/design/hw_DAA.sch
hw_DAA/BASIC

Schematic: hw_DAA.sch, sheet 34, Mechanical Parts

Parts:
FD1, FD2, FD3, FD4, FD5, FD6, FD7, FD8, FD9, FD10, FD11, FD12, FD13, FD14, FD15, FD16, FD17, FD18, FD19, FD20, FD21, FD22, FD23, FD24: NOPOP; FIDU
MP1, MP2, MP3: 7466302; WP-SMRA_746630200
MP4, MP5, MP6, MP7, MP8, MP9, MP10: 746630200; WP-SMRA_746630200
MP11, MP12, MP13, MP14: 9774050943R; WA-SMST_9774050943
PCB1: hw_DAA,BASIC-1010xx; VOID

Notes on the sheet:
1010xx
jcc5
dcs7
MECHANICAL FIXATION
BOARD PNS
FIDUCIALS
BASIC/design/hw_DAA.sch
hw_DAA/BASIC
