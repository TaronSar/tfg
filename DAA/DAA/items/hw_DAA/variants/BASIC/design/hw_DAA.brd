# Repository TaronSar/tfg (continued)

## EAGLE design DAA/DAA/items/hw_DAA/variants/BASIC/design/hw_DAA.brd (continued)

Schematic: hw_DAA.sch, sheet 17, PL High Performance Banks

Parts:
IC11: XCZU15EG-2FFVB1156I; FFVB1156_NSMD
R132, R133, R134, R135: 240,1%,0402; R0402

Connections:
!TEMP_ALERT: IC11.Y10 (IO_L6P_T0U_N10_AD6P_66); also elsewhere on the board
!TPS_INT: IC11.Y12 (IO_L5P_T0U_N8_AD14P_66); also elsewhere on the board
ACEL_INT1: IC11.AA7 (IO_L12P_T1U_N10_GC_66); also elsewhere on the board
ACEL_INT2: IC11.AA8 (IO_T1U_N12_66); also elsewhere on the board
CAN_0_RES: IC11.W11 (IO_L1N_T0L_N1_DBC_67); also elsewhere on the board
CAN_0_RX: IC11.T13 (IO_L2P_T0L_N2_67); also elsewhere on the board
CAN_0_STB: IC11.W12 (IO_L1P_T0L_N0_DBC_67); also elsewhere on the board
CAN_0_TX: IC11.R13 (IO_L2N_T0L_N3_67); also elsewhere on the board
CAN_1_RES: IC11.R12 (IO_L4N_T0U_N7_DBC_AD7N_67); also elsewhere on the board
CAN_1_RX: IC11.T10 (IO_L3N_T0L_N5_AD15N_67); also elsewhere on the board
CAN_1_STB: IC11.T12 (IO_L4P_T0U_N6_DBC_AD7P_67); also elsewhere on the board
CAN_1_TX: IC11.U10 (IO_L3P_T0L_N4_AD15P_67); also elsewhere on the board
DES_GPIO0: IC11.AE4 (IO_L18N_T2U_N11_AD2N_65); also elsewhere on the board
DES_GPIO1: IC11.AE3 (IO_L17P_T2U_N8_AD10P_65); also elsewhere on the board
DES_GPIO2: IC11.AF3 (IO_L17N_T2U_N9_AD10N_65); also elsewhere on the board
DES_GPIO3: IC11.AE2 (IO_L24P_T3U_N10_PERSTN1_I2C_SDA_65); also elsewhere on the board
DES_LOCK: IC11.AE7 (IO_L12P_T1U_N10_GC_65); also elsewhere on the board
DES_PASS: IC11.AE1 (IO_L24N_T3U_N11_PERSTN0_65); also elsewhere on the board
DES_PDB: IC11.AE8 (IO_L10P_T1U_N6_QBC_AD4P_65); also elsewhere on the board
DIS_WDOG: IC11.AK12 (IO_L1N_T0L_N1_DBC_64); also elsewhere on the board
GND: R132.1, R133.1, R134.1, R135.1; also elsewhere on the board
GPIO_1_1V8: IC11.AN7 (IO_L10P_T1U_N6_QBC_AD4P_64); also elsewhere on the board
GPIO_2_1V8: IC11.AP7 (IO_L10N_T1U_N7_QBC_AD4N_64); also elsewhere on the board
GPIO_3_1V8: IC11.AM8 (IO_L8N_T1L_N3_AD5N_64); also elsewhere on the board
GPIO_4_1V8: IC11.AK8 (IO_L11P_T1U_N8_GC_64); also elsewhere on the board
GPIO_5_1V8: IC11.AM9 (IO_L8P_T1L_N2_AD5P_64); also elsewhere on the board
GPIO_6_1V8: IC11.AK9 (IO_L9N_T1L_N5_AD12N_64); also elsewhere on the board
GPIO_OE: IC11.AJ9 (IO_L9P_T1L_N4_AD12P_64); also elsewhere on the board
GYRO_INT1: IC11.AA5 (IO_L14N_T2L_N3_GC_66); also elsewhere on the board
GYRO_INT2: IC11.AA6 (IO_L12N_T1U_N11_GC_66); also elsewhere on the board
I2C_2_SCL: IC11.Y4 (IO_L13P_T2L_N0_GC_QBC_66); also elsewhere on the board
I2C_2_SDA: IC11.Y3 (IO_L13N_T2L_N1_GC_QBC_66); also elsewhere on the board
I2C_3_SCL: IC11.AF1 (IO_L21N_T3L_N5_AD8N_65); also elsewhere on the board
I2C_3_SDA: IC11.AF2 (IO_L21P_T3L_N4_AD8P_65); also elsewhere on the board
MIPI_I_CLK_N: IC11.AF10 (IO_L1N_T0L_N1_DBC_65); also elsewhere on the board
MIPI_I_CLK_P: IC11.AE10 (IO_L1P_T0L_N0_DBC_65); also elsewhere on the board
MIPI_I_D0_N: IC11.AH11 (IO_L2N_T0L_N3_65); also elsewhere on the board
MIPI_I_D0_P: IC11.AH12 (IO_L2P_T0L_N2_65); also elsewhere on the board
MIPI_I_D1_N: IC11.AF12 (IO_L3N_T0L_N5_AD15N_65); also elsewhere on the board
MIPI_I_D1_P: IC11.AE12 (IO_L3P_T0L_N4_AD15P_65); also elsewhere on the board
MIPI_S_CLK_N: IC11.AC11 (IO_L1N_T0L_N1_DBC_66); also elsewhere on the board
MIPI_S_CLK_P: IC11.AC12 (IO_L1P_T0L_N0_DBC_66); also elsewhere on the board
MIPI_S_D0_N: IC11.AB10 (IO_L2N_T0L_N3_66); also elsewhere on the board
MIPI_S_D0_P: IC11.AB11 (IO_L2P_T0L_N2_66); also elsewhere on the board
NERROR_MCU: IC11.AJ12 (IO_L1P_T0L_N0_DBC_64); also elsewhere on the board
NINT: IC11.AM10 (IO_L3N_T0L_N5_AD15N_64); also elsewhere on the board
PMIC_GPIO10: IC11.AM11 (IO_L2N_T0L_N3_64); also elsewhere on the board
PMIC_PGOOD: IC11.AL11 (IO_L2P_T0L_N2_64); also elsewhere on the board
POC_EN: IC11.W7 (IO_L9P_T1L_N4_AD12P_66); also elsewhere on the board
TPS_GPIO: IC11.W6 (IO_L9N_T1L_N5_AD12N_66); also elsewhere on the board
TPS_SEQ: IC11.AA12 (IO_L5N_T0U_N9_AD14N_66); also elsewhere on the board
UART_2_RX: IC11.V11 (IO_L5N_T0U_N9_AD14N_67); also elsewhere on the board
UART_2_TX: IC11.V12 (IO_L5P_T0U_N8_AD14P_67); also elsewhere on the board
VRP_BK64: IC11.AN11 (IO_T0U_N12_VRP_64), R132.2
VRP_BK65: IC11.AD9 (IO_T0U_N12_VRP_65), R133.2
VRP_BK66: IC11.W9 (IO_T0U_N12_VRP_66), R134.2
VRP_BK67: IC11.W10 (IO_T0U_N12_VRP_67), R135.2
WDOG_PWM: IC11.AL10 (IO_L3P_T0L_N4_AD15P_64); also elsewhere on the board
XCLR: IC11.AB8 (IO_L8P_T1L_N2_AD5P_66); also elsewhere on the board
XHS: IC11.AC6 (IO_L7N_T1L_N1_QBC_AD13N_66); also elsewhere on the board
XTRIG: IC11.AC8 (IO_L8N_T1L_N3_AD5N_66); also elsewhere on the board
XVS: IC11.AB6 (IO_L10P_T1U_N6_QBC_AD4P_66); also elsewhere on the board

Notes on the sheet:
1010xx
jcc5
dcs7
PL HIGH PERFORMANCE BANKS
BASIC/design/hw_DAA.sch
hw_DAA/BASIC

Schematic: hw_DAA.sch, sheet 18, PS Transcievers Bank

Parts:
IC11: XCZU15EG-2FFVB1156I; FFVB1156_NSMD

Connections:
GND: IC11.A3 (MGTHRXN3_230), IC11.A4 (MGTHRXP3_230), IC11.AA31 (PS_MGTRRXP1_505), IC11.AA32 (PS_MGTRRXN1_505), IC11.AB33 (PS_MGTRRXP0_505), IC11.AB34 (PS_MGTRRXN0_505), IC11.B1 (MGTHRXN2_230), IC11.B2 (MGTHRXP2_230), IC11.B33 (MGTHRXP3_130), IC11.B34 (MGTHRXN3_130), IC11.C3 (MGTHRXN1_230), IC11.C4 (MGTHRXP1_230), IC11.C31 (MGTHRXP2_130), IC11.C32 (MGTHRXN2_130), IC11.D1 (MGTHRXN0_230), IC11.D2 (MGTHRXP0_230), IC11.D33 (MGTHRXP1_130), IC11.D34 (MGTHRXN1_130), IC11.E31 (MGTHRXP0_130), IC11.E32 (MGTHRXN0_130), IC11.F1 (MGTHRXN3_229), IC11.F2 (MGTHRXP3_229), IC11.F33 (MGTHRXP3_129), IC11.F34 (MGTHRXN3_129), IC11.H1 (MGTHRXN2_229), IC11.H2 (MGTHRXP2_229), IC11.H33 (MGTHRXP2_129), IC11.H34 (MGTHRXN2_129), IC11.J3 (MGTHRXN1_229), IC11.J4 (MGTHRXP1_229), IC11.K1 (MGTHRXN0_229), IC11.K2 (MGTHRXP0_229), IC11.K33 (MGTHRXP1_129), IC11.K34 (MGTHRXN1_129), IC11.L3 (MGTHRXN3_228), IC11.L4 (MGTHRXP3_228), IC11.L31 (MGTHRXP0_129), IC11.L32 (MGTHRXN0_129), IC11.M1 (MGTHRXN2_228), IC11.M2 (MGTHRXP2_228), IC11.M33 (MGTHRXP3_128), IC11.M34 (MGTHRXN3_128), IC11.N31 (MGTHRXP2_128), IC11.N32 (MGTHRXN2_128), IC11.P1 (MGTHRXN1_228), IC11.P2 (MGTHRXP1_228), IC11.P33 (MGTHRXP1_128), IC11.P34 (MGTHRXN1_128), IC11.T1 (MGTHRXN0_228), IC11.T2 (MGTHRXP0_228), IC11.T33 (MGTHRXP0_128), IC11.T34 (MGTHRXN0_128), IC11.V33 (PS_MGTRRXP3_505), IC11.V34 (PS_MGTRRXN3_505), IC11.Y33 (PS_MGTRRXP2_505), IC11.Y34 (PS_MGTRRXN2_505); also elsewhere on the board

Notes on the sheet:
1010xx
jcc5
dcs7
PS TRANSCIEVER BANKS
BASIC/design/hw_DAA.sch
hw_DAA/BASIC

Schematic: hw_DAA.sch, sheet 19, PS MIO Banks

Parts:
IC11: XCZU15EG-2FFVB1156I; FFVB1156_NSMD

Connections:
!RS485_RE: IC11.AK17 (PS_MIO13); also elsewhere on the board
ETH_GPIO0: IC11.E25 (PS_MIO72); also elsewhere on the board
ETH_GPIO1: IC11.H24 (PS_MIO73); also elsewhere on the board
ETH_GTX_CLK: IC11.F22 (PS_MIO52); also elsewhere on the board
ETH_INT_PWDN: IC11.G25 (PS_MIO74); also elsewhere on the board
ETH_MDC: IC11.H25 (PS_MIO76); also elsewhere on the board
ETH_MDIO: IC11.F25 (PS_MIO77); also elsewhere on the board
ETH_RSTN: IC11.D25 (PS_MIO75); also elsewhere on the board
ETH_RX_CLK: IC11.G23 (PS_MIO58); also elsewhere on the board
ETH_RX_CTRL: IC11.D24 (PS_MIO63); also elsewhere on the board
ETH_RX_D0: IC11.B24 (PS_MIO59); also elsewhere on the board
ETH_RX_D1: IC11.E24 (PS_MIO60); also elsewhere on the board
ETH_RX_D2: IC11.C24 (PS_MIO61); also elsewhere on the board
ETH_RX_D3: IC11.G24 (PS_MIO62); also elsewhere on the board
ETH_TX_CTRL: IC11.A23 (PS_MIO57); also elsewhere on the board
ETH_TX_D0: IC11.E23 (PS_MIO53); also elsewhere on the board
ETH_TX_D1: IC11.F23 (PS_MIO54); also elsewhere on the board
ETH_TX_D2: IC11.B23 (PS_MIO55); also elsewhere on the board
ETH_TX_D3: IC11.C23 (PS_MIO56); also elsewhere on the board
I2C_0_SCL: IC11.M24 (PS_MIO42); also elsewhere on the board
I2C_0_SDA: IC11.K24 (PS_MIO43); also elsewhere on the board
I2C_1_SCL: IC11.H22 (PS_MIO32); also elsewhere on the board
I2C_1_SDA: IC11.H23 (PS_MIO33); also elsewhere on the board
I2C_PMIC_SEL: IC11.J24 (PS_MIO41); also elsewhere on the board
ID0: IC11.AE18 (PS_MIO18); also elsewhere on the board
ID1: IC11.AE19 (PS_MIO25); also elsewhere on the board
ID2: IC11.AE20 (PS_MIO24); also elsewhere on the board
RS485_DE: IC11.AJ17 (PS_MIO12); also elsewhere on the board
RS485_RES_RX: IC11.AF17 (PS_MIO11); also elsewhere on the board
RS485_RES_TX: IC11.AH17 (PS_MIO10); also elsewhere on the board
SDIO_1_CLK: IC11.N25 (PS_MIO51); also elsewhere on the board
SDIO_1_CMD: IC11.P25 (PS_MIO50); also elsewhere on the board
SDIO_1_DAT0: IC11.J25 (PS_MIO46); also elsewhere on the board
SDIO_1_DAT1: IC11.L25 (PS_MIO47); also elsewhere on the board
SDIO_1_DAT2: IC11.M25 (PS_MIO48); also elsewhere on the board
SDIO_1_DAT3: IC11.K25 (PS_MIO49); also elsewhere on the board
SDIO_1_SEL: IC11.N23 (PS_MIO39); also elsewhere on the board
UART_0_RX: IC11.AL16 (PS_MIO14); also elsewhere on the board
UART_0_TX: IC11.AN16 (PS_MIO15); also elsewhere on the board
UART_1_RX: IC11.AJ16 (PS_MIO1); also elsewhere on the board
UART_1_TX: IC11.AF16 (PS_MIO0); also elsewhere on the board

Notes on the sheet:
1010xx
jcc5
dcs7
PS MIO BANKS
BASIC/design/hw_DAA.sch
hw_DAA/BASIC

Schematic: hw_DAA.sch, sheet 20, PS DDR Memory Bank

Parts:
IC11: XCZU15EG-2FFVB1156I; FFVB1156_NSMD
R136: 240,1%,0402; R0402

Connections:
DDR4_A0: IC11.AP29 (PS_DDR_A0); also elsewhere on the board
DDR4_A1: IC11.AP30 (PS_DDR_A1); also elsewhere on the board
DDR4_A2: IC11.AP26 (PS_DDR_A2); also elsewhere on the board
DDR4_A3: IC11.AP27 (PS_DDR_A3); also elsewhere on the board
DDR4_A4: IC11.AP25 (PS_DDR_A4); also elsewhere on the board
DDR4_A5: IC11.AN24 (PS_DDR_A5); also elsewhere on the board
DDR4_A6: IC11.AM29 (PS_DDR_A6); also elsewhere on the board
DDR4_A7: IC11.AM28 (PS_DDR_A7); also elsewhere on the board
DDR4_A8: IC11.AM26 (PS_DDR_A8); also elsewhere on the board
DDR4_A9: IC11.AM25 (PS_DDR_A9); also elsewhere on the board
DDR4_A10_AP: IC11.AL28 (PS_DDR_A10); also elsewhere on the board
DDR4_A11: IC11.AK27 (PS_DDR_A11); also elsewhere on the board
DDR4_A12_BCN: IC11.AJ25 (PS_DDR_A12); also elsewhere on the board
DDR4_A13: IC11.AL25 (PS_DDR_A13); also elsewhere on the board
DDR4_A14_WEN: IC11.AK25 (PS_DDR_A14); also elsewhere on the board
DDR4_A15_CASN: IC11.AK24 (PS_DDR_A15); also elsewhere on the board
DDR4_A16_RASN: IC11.AM24 (PS_DDR_A16); also elsewhere on the board
DDR4_ACT_N: IC11.AG25 (PS_DDR_ACT_N); also elsewhere on the board
DDR4_ALERT_N: IC11.AF22 (PS_DDR_ALERT_N); also elsewhere on the board
DDR4_BA0: IC11.AH26 (PS_DDR_BA0); also elsewhere on the board
DDR4_BA1: IC11.AG26 (PS_DDR_BA1); also elsewhere on the board
DDR4_BG0: IC11.AK28 (PS_DDR_BG0); also elsewhere on the board
DDR4_CK0_N: IC11.AN27 (PS_DDR_CK_N0); also elsewhere on the board
DDR4_CK0_P: IC11.AN26 (PS_DDR_CK0); also elsewhere on the board
DDR4_CKE0: IC11.AN29 (PS_DDR_CKE0); also elsewhere on the board
DDR4_CS0_N: IC11.AN28 (PS_DDR_CS_N0); also elsewhere on the board
DDR4_DM0: IC11.AN17 (PS_DDR_DM0); also elsewhere on the board
DDR4_DM1: IC11.AM21 (PS_DDR_DM1); also elsewhere on the board
DDR4_DM2: IC11.AK19 (PS_DDR_DM2); also elsewhere on the board
DDR4_DM3: IC11.AH24 (PS_DDR_DM3); also elsewhere on the board
DDR4_DM4: IC11.AH31 (PS_DDR_DM4); also elsewhere on the board
DDR4_DM5: IC11.AE30 (PS_DDR_DM5); also elsewhere on the board
DDR4_DM6: IC11.AJ31 (PS_DDR_DM6); also elsewhere on the board
DDR4_DM7: IC11.AE34 (PS_DDR_DM7); also elsewhere on the board
DDR4_DM8: IC11.AN34 (PS_DDR_DM8); also elsewhere on the board
DDR4_DQ0: IC11.AP20 (PS_DDR_DQ0); also elsewhere on the board
DDR4_DQ1: IC11.AP18 (PS_DDR_DQ1); also elsewhere on the board
DDR4_DQ2: IC11.AP19 (PS_DDR_DQ2); also elsewhere on the board
DDR4_DQ3: IC11.AP17 (PS_DDR_DQ3); also elsewhere on the board
DDR4_DQ4: IC11.AM20 (PS_DDR_DQ4); also elsewhere on the board
DDR4_DQ5: IC11.AM19 (PS_DDR_DQ5); also elsewhere on the board
DDR4_DQ6: IC11.AM18 (PS_DDR_DQ6); also elsewhere on the board
DDR4_DQ7: IC11.AL18 (PS_DDR_DQ7); also elsewhere on the board
DDR4_DQ8: IC11.AP22 (PS_DDR_DQ8); also elsewhere on the board
DDR4_DQ9: IC11.AP21 (PS_DDR_DQ9); also elsewhere on the board
DDR4_DQ10: IC11.AP24 (PS_DDR_DQ10); also elsewhere on the board
DDR4_DQ11: IC11.AN23 (PS_DDR_DQ11); also elsewhere on the board
DDR4_DQ12: IC11.AL21 (PS_DDR_DQ12); also elsewhere on the board
DDR4_DQ13: IC11.AL22 (PS_DDR_DQ13); also elsewhere on the board
DDR4_DQ14: IC11.AM23 (PS_DDR_DQ14); also elsewhere on the board
DDR4_DQ15: IC11.AL23 (PS_DDR_DQ15); also elsewhere on the board
DDR4_DQ16: IC11.AL20 (PS_DDR_DQ16); also elsewhere on the board
DDR4_DQ17: IC11.AK20 (PS_DDR_DQ17); also elsewhere on the board
DDR4_DQ18: IC11.AJ20 (PS_DDR_DQ18); also elsewhere on the board
DDR4_DQ19: IC11.AK18 (PS_DDR_DQ19); also elsewhere on the board
DDR4_DQ20: IC11.AG20 (PS_DDR_DQ20); also elsewhere on the board
DDR4_DQ21: IC11.AH18 (PS_DDR_DQ21); also elsewhere on the board
DDR4_DQ22: IC11.AG19 (PS_DDR_DQ22); also elsewhere on the board
DDR4_DQ23: IC11.AG18 (PS_DDR_DQ23); also elsewhere on the board
DDR4_DQ24: IC11.AG21 (PS_DDR_DQ24); also elsewhere on the board
DDR4_DQ25: IC11.AH21 (PS_DDR_DQ25); also elsewhere on the board
DDR4_DQ26: IC11.AG24 (PS_DDR_DQ26); also elsewhere on the board
DDR4_DQ27: IC11.AG23 (PS_DDR_DQ27); also elsewhere on the board
DDR4_DQ28: IC11.AK22 (PS_DDR_DQ28); also elsewhere on the board
DDR4_DQ29: IC11.AJ21 (PS_DDR_DQ29); also elsewhere on the board
DDR4_DQ30: IC11.AJ22 (PS_DDR_DQ30); also elsewhere on the board
DDR4_DQ31: IC11.AK23 (PS_DDR_DQ31); also elsewhere on the board
DDR4_DQ32: IC11.AG31 (PS_DDR_DQ32); also elsewhere on the board
DDR4_DQ33: IC11.AG30 (PS_DDR_DQ33); also elsewhere on the board
DDR4_DQ34: IC11.AG29 (PS_DDR_DQ34); also elsewhere on the board
DDR4_DQ35: IC11.AG28 (PS_DDR_DQ35); also elsewhere on the board
DDR4_DQ36: IC11.AJ30 (PS_DDR_DQ36); also elsewhere on the board
DDR4_DQ37: IC11.AK29 (PS_DDR_DQ37); also elsewhere on the board
DDR4_DQ38: IC11.AK30 (PS_DDR_DQ38); also elsewhere on the board
DDR4_DQ39: IC11.AJ29 (PS_DDR_DQ39); also elsewhere on the board
DDR4_DQ40: IC11.AE27 (PS_DDR_DQ40); also elsewhere on the board
DDR4_DQ41: IC11.AF28 (PS_DDR_DQ41); also elsewhere on the board
DDR4_DQ42: IC11.AF30 (PS_DDR_DQ42); also elsewhere on the board
DDR4_DQ43: IC11.AF31 (PS_DDR_DQ43); also elsewhere on the board
DDR4_DQ44: IC11.AD28 (PS_DDR_DQ44); also elsewhere on the board
DDR4_DQ45: IC11.AD27 (PS_DDR_DQ45); also elsewhere on the board
DDR4_DQ46: IC11.AD29 (PS_DDR_DQ46); also elsewhere on the board
DDR4_DQ47: IC11.AD30 (PS_DDR_DQ47); also elsewhere on the board
DDR4_DQ48: IC11.AH33 (PS_DDR_DQ48); also elsewhere on the board
DDR4_DQ49: IC11.AJ34 (PS_DDR_DQ49); also elsewhere on the board
DDR4_DQ50: IC11.AH34 (PS_DDR_DQ50); also elsewhere on the board
DDR4_DQ51: IC11.AH32 (PS_DDR_DQ51); also elsewhere on the board
DDR4_DQ52: IC11.AK34 (PS_DDR_DQ52); also elsewhere on the board
DDR4_DQ53: IC11.AK33 (PS_DDR_DQ53); also elsewhere on the board
DDR4_DQ54: IC11.AL32 (PS_DDR_DQ54); also elsewhere on the board
DDR4_DQ55: IC11.AL31 (PS_DDR_DQ55); also elsewhere on the board
DDR4_DQ56: IC11.AG33 (PS_DDR_DQ56); also elsewhere on the board
DDR4_DQ57: IC11.AG34 (PS_DDR_DQ57); also elsewhere on the board
DDR4_DQ58: IC11.AF32 (PS_DDR_DQ58); also elsewhere on the board
DDR4_DQ59: IC11.AF33 (PS_DDR_DQ59); also elsewhere on the board
DDR4_DQ60: IC11.AD31 (PS_DDR_DQ60); also elsewhere on the board
DDR4_DQ61: IC11.AD32 (PS_DDR_DQ61); also elsewhere on the board
DDR4_DQ62: IC11.AD34 (PS_DDR_DQ62); also elsewhere on the board
DDR4_DQ63: IC11.AD33 (PS_DDR_DQ63); also elsewhere on the board
DDR4_DQ64: IC11.AN31 (PS_DDR_DQ64); also elsewhere on the board
DDR4_DQ65: IC11.AP31 (PS_DDR_DQ65); also elsewhere on the board
DDR4_DQ66: IC11.AP32 (PS_DDR_DQ66); also elsewhere on the board
DDR4_DQ67: IC11.AP33 (PS_DDR_DQ67); also elsewhere on the board
DDR4_DQ68: IC11.AM31 (PS_DDR_DQ68); also elsewhere on the board
DDR4_DQ69: IC11.AM33 (PS_DDR_DQ69); also elsewhere on the board
DDR4_DQ70: IC11.AM34 (PS_DDR_DQ70); also elsewhere on the board
DDR4_DQ71: IC11.AL33 (PS_DDR_DQ71); also elsewhere on the board
DDR4_DQS0_N: IC11.AN19 (PS_DDR_DQS_N0); also elsewhere on the board
DDR4_DQS0_P: IC11.AN18 (PS_DDR_DQS_P0); also elsewhere on the board
DDR4_DQS1_N: IC11.AN22 (PS_DDR_DQS_N1); also elsewhere on the board
DDR4_DQS1_P: IC11.AN21 (PS_DDR_DQS_P1); also elsewhere on the board
DDR4_DQS2_N: IC11.AJ19 (PS_DDR_DQS_N2); also elsewhere on the board
DDR4_DQS2_P: IC11.AH19 (PS_DDR_DQS_P2); also elsewhere on the board
DDR4_DQS3_N: IC11.AH23 (PS_DDR_DQS_N3); also elsewhere on the board
DDR4_DQS3_P: IC11.AH22 (PS_DDR_DQS_P3); also elsewhere on the board
DDR4_DQS4_N: IC11.AH29 (PS_DDR_DQS_N4); also elsewhere on the board
DDR4_DQS4_P: IC11.AH28 (PS_DDR_DQS_P4); also elsewhere on the board
DDR4_DQS5_N: IC11.AE29 (PS_DDR_DQS_N5); also elsewhere on the board
DDR4_DQS5_P: IC11.AE28 (PS_DDR_DQS_P5); also elsewhere on the board
DDR4_DQS6_N: IC11.AK32 (PS_DDR_DQS_N6); also elsewhere on the board
DDR4_DQS6_P: IC11.AJ32 (PS_DDR_DQS_P6); also elsewhere on the board
DDR4_DQS7_N: IC11.AE33 (PS_DDR_DQS_N7); also elsewhere on the board
DDR4_DQS7_P: IC11.AE32 (PS_DDR_DQS_P7); also elsewhere on the board
DDR4_DQS8_N: IC11.AN33 (PS_DDR_DQS_N8); also elsewhere on the board
DDR4_DQS8_P: IC11.AN32 (PS_DDR_DQS_P8); also elsewhere on the board
DDR4_ODT0: IC11.AM30 (PS_DDR_ODT0); also elsewhere on the board
DDR4_PAR: IC11.AF20 (PS_DDR_PARITY); also elsewhere on the board
DDR4_RESET_N: IC11.AF21 (PS_DDR_RAM_RST_N); also elsewhere on the board
DDR4_ZQ: IC11.AF23 (PS_DDR_ZQ), R136.2
GND: R136.1; also elsewhere on the board

Notes on the sheet:
1010xx
jcc5
dcs7
BANK 504 DDR4 MEMORY
BASIC/design/hw_DAA.sch
hw_DAA/BASIC

Schematic: hw_DAA.sch, sheet 21, DDR4 Memories 1-2

Parts:
C201, C202, C203, C204, C205, C206, C207, C208, C210, C211: 4.7uF,20%,0402,10V; C0402
C209, C212, C215, C218, C219, C220, C222, C223: 1uF,10%,0402,25V; C0402
C213, C214, C216, C217: 2.2uF,10%,0402,16V; C0402
C221, C224, C225, C226, C227, C228, C465, C473: 100nF,10%,0402,50V; C0402
C255, C463, C466, C469: 470nF,10%,0402,16V; C0402
C256, C464, C467, C471: 68nF,10%,0402,50V; C0402
IC14, IC15: MT40A1G16TD-062E AAT_F; FBGA96_NSMD_MICRON
R137, R139: 240,1%,0402; R0402
R138, R140: 499,1%,0402; R0402

Connections:
DDR4_A0: IC14.P3 (A0), IC15.P3 (A0); also elsewhere on the board
DDR4_A1: IC14.P7 (A1), IC15.P7 (A1); also elsewhere on the board
DDR4_A2: IC14.R3 (A2), IC15.R3 (A2); also elsewhere on the board
DDR4_A3: IC14.N7 (A3), IC15.N7 (A3); also elsewhere on the board
DDR4_A4: IC14.N3 (A4), IC15.N3 (A4); also elsewhere on the board
DDR4_A5: IC14.P8 (A5), IC15.P8 (A5); also elsewhere on the board
DDR4_A6: IC14.P2 (A6), IC15.P2 (A6); also elsewhere on the board
DDR4_A7: IC14.R8 (A7), IC15.R8 (A7); also elsewhere on the board
DDR4_A8: IC14.R2 (A8), IC15.R2 (A8); also elsewhere on the board
DDR4_A9: IC14.R7 (A9), IC15.R7 (A9); also elsewhere on the board
DDR4_A10_AP: IC14.M3 (A10/AP), IC15.M3 (A10/AP); also elsewhere on the board
DDR4_A11: IC14.T2 (A11), IC15.T2 (A11); also elsewhere on the board
DDR4_A12_BCN: IC14.M7 (A12/BC_N), IC15.M7 (A12/BC_N); also elsewhere on the board
DDR4_A13: IC14.T8 (A13), IC15.T8 (A13); also elsewhere on the board
DDR4_A14_WEN: IC14.L2 (A14/WE_N), IC15.L2 (A14/WE_N); also elsewhere on the board
DDR4_A15_CASN: IC14.M8 (A15/CAS_N), IC15.M8 (A15/CAS_N); also elsewhere on the board
DDR4_A16_RASN: IC14.L8 (A16/RAS_N), IC15.L8 (A16/RAS_N); also elsewhere on the board
DDR4_ACT_N: IC14.L3 (ACT_N), IC15.L3 (ACT_N); also elsewhere on the board
DDR4_ALERT_N: IC14.P9 (ALERT_N), IC15.P9 (ALERT_N); also elsewhere on the board
DDR4_BA0: IC14.N2 (BA0), IC15.N2 (BA0); also elsewhere on the board
DDR4_BA1: IC14.N8 (BA1), IC15.N8 (BA1); also elsewhere on the board
DDR4_BG0: IC14.M2 (BG0), IC15.M2 (BG0); also elsewhere on the board
DDR4_CK0_N: IC14.K8 (CK_C), IC15.K8 (CK_C); also elsewhere on the board
DDR4_CK0_P: IC14.K7 (CK_T), IC15.K7 (CK_T); also elsewhere on the board
DDR4_CKE0: IC14.K2 (CKE), IC15.K2 (CKE); also elsewhere on the board
DDR4_CS0_N: IC14.L7 (CS_N), IC15.L7 (CS_N); also elsewhere on the board
DDR4_DM0: IC14.E7 (LDM_N/LDBI_N); also elsewhere on the board
DDR4_DM1: IC14.E2 (UDM_N/UDBI_N); also elsewhere on the board
DDR4_DM2: IC15.E7 (LDM_N/LDBI_N); also elsewhere on the board
DDR4_DM3: IC15.E2 (UDM_N/UDBI_N); also elsewhere on the board
DDR4_DQ0: IC14.G2 (DQ0); also elsewhere on the board
DDR4_DQ1: IC14.F7 (DQ1); also elsewhere on the board
DDR4_DQ2: IC14.H3 (DQ2); also elsewhere on the board
DDR4_DQ3: IC14.H7 (DQ3); also elsewhere on the board
DDR4_DQ4: IC14.H2 (DQ4); also elsewhere on the board
DDR4_DQ5: IC14.H8 (DQ5); also elsewhere on the board
DDR4_DQ6: IC14.J3 (DQ6); also elsewhere on the board
DDR4_DQ7: IC14.J7 (DQ7); also elsewhere on the board
DDR4_DQ8: IC14.A3 (DQ8); also elsewhere on the board
DDR4_DQ9: IC14.B8 (DQ9); also elsewhere on the board
DDR4_DQ10: IC14.C3 (DQ10); also elsewhere on the board
DDR4_DQ11: IC14.C7 (DQ11); also elsewhere on the board
DDR4_DQ12: IC14.C2 (DQ12); also elsewhere on the board
DDR4_DQ13: IC14.C8 (DQ13); also elsewhere on the board
DDR4_DQ14: IC14.D3 (DQ14); also elsewhere on the board
DDR4_DQ15: IC14.D7 (DQ15); also elsewhere on the board
DDR4_DQ16: IC15.G2 (DQ0); also elsewhere on the board
DDR4_DQ17: IC15.F7 (DQ1); also elsewhere on the board
DDR4_DQ18: IC15.H3 (DQ2); also elsewhere on the board
DDR4_DQ19: IC15.H7 (DQ3); also elsewhere on the board
DDR4_DQ20: IC15.H2 (DQ4); also elsewhere on the board
DDR4_DQ21: IC15.H8 (DQ5); also elsewhere on the board
DDR4_DQ22: IC15.J3 (DQ6); also elsewhere on the board
DDR4_DQ23: IC15.J7 (DQ7); also elsewhere on the board
DDR4_DQ24: IC15.A3 (DQ8); also elsewhere on the board
DDR4_DQ25: IC15.B8 (DQ9); also elsewhere on the board
DDR4_DQ26: IC15.C3 (DQ10); also elsewhere on the board
DDR4_DQ27: IC15.C7 (DQ11); also elsewhere on the board
DDR4_DQ28: IC15.C2 (DQ12); also elsewhere on the board
DDR4_DQ29: IC15.C8 (DQ13); also elsewhere on the board
DDR4_DQ30: IC15.D3 (DQ14); also elsewhere on the board
DDR4_DQ31: IC15.D7 (DQ15); also elsewhere on the board
DDR4_DQS0_N: IC14.F3 (LDQS_C); also elsewhere on the board
DDR4_DQS0_P: IC14.G3 (LDQS_T); also elsewhere on the board
DDR4_DQS1_N: IC14.A7 (UDQS_C); also elsewhere on the board
DDR4_DQS1_P: IC14.B7 (UDQS_T); also elsewhere on the board
DDR4_DQS2_N: IC15.F3 (LDQS_C); also elsewhere on the board
DDR4_DQS2_P: IC15.G3 (LDQS_T); also elsewhere on the board
DDR4_DQS3_N: IC15.A7 (UDQS_C); also elsewhere on the board
DDR4_DQS3_P: IC15.B7 (UDQS_T); also elsewhere on the board
DDR4_ODT0: IC14.K3 (ODT), IC15.K3 (ODT); also elsewhere on the board
DDR4_PAR: IC14.T3 (PAR), IC15.T3 (PAR); also elsewhere on the board
DDR4_RESET_N: IC14.P1 (RESET_N), IC15.P1 (RESET_N); also elsewhere on the board
DDR4_TEN_0: IC14.N9 (TEN), R138.1
DDR4_TEN_1: IC15.N9 (TEN), R140.1
DDR4_ZQ_0: IC14.F9 (ZQ), R137.2
DDR4_ZQ_1: IC15.F9 (ZQ), R139.2
GND: C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, C207.2, C208.2, C209.2, C210.2, C211.2, C212.2, C213.2, C214.2, C215.2, C216.2, C217.2, C218.2, C219.2, C220.2, C221.2, C222.2, C223.2, C224.2, C225.2, C226.2, C227.2, C228.2, C255.2, C256.2, C463.2, C464.2, C465.2, C466.2, C467.2, C469.2, C471.2, C473.2, IC14.A2 (VSSQ_1), IC14.A8 (VSSQ_2), IC14.B2 (VSS_1), IC14.C9 (VSSQ_3), IC14.D2 (VSSQ_4), IC14.D8 (VSSQ_5), IC14.E1 (VSS_2), IC14.E3 (VSSQ_6), IC14.E8 (VSSQ_7), IC14.E9 (VSS_3), IC14.F1 (VSSQ_8), IC14.G8 (VSS_4), IC14.H1 (VSSQ_9), IC14.H9 (VSSQ_10), IC14.K1 (VSS_5), IC14.K9 (VSS_6), IC14.M9 (VSS_7), IC14.N1 (VSS_8), IC14.T1 (VSS_9), IC15.A2 (VSSQ_1), IC15.A8 (VSSQ_2), IC15.B2 (VSS_1), IC15.C9 (VSSQ_3), IC15.D2 (VSSQ_4), IC15.D8 (VSSQ_5), IC15.E1 (VSS_2), IC15.E3 (VSSQ_6), IC15.E8 (VSSQ_7), IC15.E9 (VSS_3), IC15.F1 (VSSQ_8), IC15.G8 (VSS_4), IC15.H1 (VSSQ_9), IC15.H9 (VSSQ_10), IC15.K1 (VSS_5), IC15.K9 (VSS_6), IC15.M9 (VSS_7), IC15.N1 (VSS_8), IC15.T1 (VSS_9), R137.1, R138.2, R139.1, R140.2; also elsewhere on the board
PSDDR: C201.1, C202.1, C204.1, C205.1, C207.1, C208.1, C210.1, C211.1, C213.1, C214.1, C216.1, C217.1, C219.1, C220.1, C222.1, C223.1, C225.1, C226.1, C227.1, C228.1, C255.1, C256.1, C463.1, C464.1, C466.1, C467.1, C469.1, C471.1, IC14.A1 (VDDQ_1), IC14.A9 (VDDQ_2), IC14.B3 (VDD_1), IC14.B9 (VDD_2), IC14.C1 (VDDQ_3), IC14.D1 (VDD_3), IC14.D9 (VDDQ_4), IC14.F2 (VDDQ_5), IC14.F8 (VDDQ_6), IC14.G1 (VDDQ_7), IC14.G7 (VDD_6), IC14.G9 (VDDQ_8), IC14.J1 (VDD_4), IC14.J2 (VDDQ_9), IC14.J8 (VDDQ_10), IC14.J9 (VDD_5), IC14.L1 (VDD_10), IC14.L9 (VDD_7), IC14.R1 (VDD_8), IC14.T9 (VDD_9), IC15.A1 (VDDQ_1), IC15.A9 (VDDQ_2), IC15.B3 (VDD_1), IC15.B9 (VDD_2), IC15.C1 (VDDQ_3), IC15.D1 (VDD_3), IC15.D9 (VDDQ_4), IC15.F2 (VDDQ_5), IC15.F8 (VDDQ_6), IC15.G1 (VDDQ_7), IC15.G7 (VDD_6), IC15.G9 (VDDQ_8), IC15.J1 (VDD_4), IC15.J2 (VDDQ_9), IC15.J8 (VDDQ_10), IC15.J9 (VDD_5), IC15.L1 (VDD_10), IC15.L9 (VDD_7), IC15.R1 (VDD_8), IC15.T9 (VDD_9); also elsewhere on the board
VPP: C203.1, C206.1, C209.1, C212.1, C215.1, C218.1, C465.1, C473.1, IC14.B1 (VPP_1), IC14.R9 (VPP_2), IC15.B1 (VPP_1), IC15.R9 (VPP_2); also elsewhere on the board
VTTREF: C221.1, C224.1, IC14.M1 (VREFCA), IC15.M1 (VREFCA); also elsewhere on the board

Notes on the sheet:
1010xx
jcc5
dcs7
1.2V
2.5V
0.6V
DDR4 MEMORY 2
DDR4 MEMORY 1
BASIC/design/hw_DAA.sch
hw_DAA/BASIC

Schematic: hw_DAA.sch, sheet 22, DRR4 Memories 3-4

Parts:
C229, C230, C231, C232, C233, C234, C235, C236, C238, C239: 4.7uF,20%,0402,10V; C0402
C237, C240, C243, C246, C247, C248, C250, C251: 1uF,10%,0402,25V; C0402
C241, C242, C244, C245: 2.2uF,10%,0402,16V; C0402
C249, C252, C253, C254, C468, C470, C472, C478: 100nF,10%,0402,50V; C0402
C474, C476, C479, C481: 470nF,10%,0402,16V; C0402
C475, C477, C480, C482: 68nF,10%,0402,50V; C0402
IC16, IC17: MT40A1G16TD-062E AAT_F; FBGA96_NSMD_MICRON
R141, R143: 240,1%,0402; R0402
R142, R144: 499,1%,0402; R0402

Connections:
DDR4_A0: IC16.P3 (A0), IC17.P3 (A0); also elsewhere on the board
DDR4_A1: IC16.P7 (A1), IC17.P7 (A1); also elsewhere on the board
DDR4_A2: IC16.R3 (A2), IC17.R3 (A2); also elsewhere on the board
DDR4_A3: IC16.N7 (A3), IC17.N7 (A3); also elsewhere on the board
DDR4_A4: IC16.N3 (A4), IC17.N3 (A4); also elsewhere on the board
DDR4_A5: IC16.P8 (A5), IC17.P8 (A5); also elsewhere on the board
DDR4_A6: IC16.P2 (A6), IC17.P2 (A6); also elsewhere on the board
DDR4_A7: IC16.R8 (A7), IC17.R8 (A7); also elsewhere on the board
DDR4_A8: IC16.R2 (A8), IC17.R2 (A8); also elsewhere on the board
DDR4_A9: IC16.R7 (A9), IC17.R7 (A9); also elsewhere on the board
DDR4_A10_AP: IC16.M3 (A10/AP), IC17.M3 (A10/AP); also elsewhere on the board
DDR4_A11: IC16.T2 (A11), IC17.T2 (A11); also elsewhere on the board
DDR4_A12_BCN: IC16.M7 (A12/BC_N), IC17.M7 (A12/BC_N); also elsewhere on the board
DDR4_A13: IC16.T8 (A13), IC17.T8 (A13); also elsewhere on the board
DDR4_A14_WEN: IC16.L2 (A14/WE_N), IC17.L2 (A14/WE_N); also elsewhere on the board
DDR4_A15_CASN: IC16.M8 (A15/CAS_N), IC17.M8 (A15/CAS_N); also elsewhere on the board
DDR4_A16_RASN: IC16.L8 (A16/RAS_N), IC17.L8 (A16/RAS_N); also elsewhere on the board
DDR4_ACT_N: IC16.L3 (ACT_N), IC17.L3 (ACT_N); also elsewhere on the board
DDR4_ALERT_N: IC16.P9 (ALERT_N), IC17.P9 (ALERT_N); also elsewhere on the board
DDR4_BA0: IC16.N2 (BA0), IC17.N2 (BA0); also elsewhere on the board
DDR4_BA1: IC16.N8 (BA1), IC17.N8 (BA1); also elsewhere on the board
DDR4_BG0: IC16.M2 (BG0), IC17.M2 (BG0); also elsewhere on the board
DDR4_CK0_N: IC16.K8 (CK_C), IC17.K8 (CK_C); also elsewhere on the board
DDR4_CK0_P: IC16.K7 (CK_T), IC17.K7 (CK_T); also elsewhere on the board
DDR4_CKE0: IC16.K2 (CKE), IC17.K2 (CKE); also elsewhere on the board
DDR4_CS0_N: IC16.L7 (CS_N), IC17.L7 (CS_N); also elsewhere on the board
DDR4_DM4: IC16.E7 (LDM_N/LDBI_N); also elsewhere on the board
DDR4_DM5: IC16.E2 (UDM_N/UDBI_N); also elsewhere on the board
DDR4_DM6: IC17.E7 (LDM_N/LDBI_N); also elsewhere on the board
DDR4_DM7: IC17.E2 (UDM_N/UDBI_N); also elsewhere on the board
DDR4_DQ32: IC16.G2 (DQ0); also elsewhere on the board
DDR4_DQ33: IC16.F7 (DQ1); also elsewhere on the board
DDR4_DQ34: IC16.H3 (DQ2); also elsewhere on the board
DDR4_DQ35: IC16.H7 (DQ3); also elsewhere on the board
DDR4_DQ36: IC16.H2 (DQ4); also elsewhere on the board
DDR4_DQ37: IC16.H8 (DQ5); also elsewhere on the board
DDR4_DQ38: IC16.J3 (DQ6); also elsewhere on the board
DDR4_DQ39: IC16.J7 (DQ7); also elsewhere on the board
DDR4_DQ40: IC16.A3 (DQ8); also elsewhere on the board
DDR4_DQ41: IC16.B8 (DQ9); also elsewhere on the board
DDR4_DQ42: IC16.C3 (DQ10); also elsewhere on the board
DDR4_DQ43: IC16.C7 (DQ11); also elsewhere on the board
DDR4_DQ44: IC16.C2 (DQ12); also elsewhere on the board
DDR4_DQ45: IC16.C8 (DQ13); also elsewhere on the board
DDR4_DQ46: IC16.D3 (DQ14); also elsewhere on the board
DDR4_DQ47: IC16.D7 (DQ15); also elsewhere on the board
DDR4_DQ48: IC17.G2 (DQ0); also elsewhere on the board
DDR4_DQ49: IC17.F7 (DQ1); also elsewhere on the board
DDR4_DQ50: IC17.H3 (DQ2); also elsewhere on the board
DDR4_DQ51: IC17.H7 (DQ3); also elsewhere on the board
DDR4_DQ52: IC17.H2 (DQ4); also elsewhere on the board
DDR4_DQ53: IC17.H8 (DQ5); also elsewhere on the board
DDR4_DQ54: IC17.J3 (DQ6); also elsewhere on the board
DDR4_DQ55: IC17.J7 (DQ7); also elsewhere on the board
DDR4_DQ56: IC17.A3 (DQ8); also elsewhere on the board
DDR4_DQ57: IC17.B8 (DQ9); also elsewhere on the board
DDR4_DQ58: IC17.C3 (DQ10); also elsewhere on the board
DDR4_DQ59: IC17.C7 (DQ11); also elsewhere on the board
DDR4_DQ60: IC17.C2 (DQ12); also elsewhere on the board
DDR4_DQ61: IC17.C8 (DQ13); also elsewhere on the board
DDR4_DQ62: IC17.D3 (DQ14); also elsewhere on the board
DDR4_DQ63: IC17.D7 (DQ15); also elsewhere on the board
DDR4_DQS4_N: IC16.F3 (LDQS_C); also elsewhere on the board
DDR4_DQS4_P: IC16.G3 (LDQS_T); also elsewhere on the board
DDR4_DQS5_N: IC16.A7 (UDQS_C); also elsewhere on the board
DDR4_DQS5_P: IC16.B7 (UDQS_T); also elsewhere on the board
DDR4_DQS6_N: IC17.F3 (LDQS_C); also elsewhere on the board
DDR4_DQS6_P: IC17.G3 (LDQS_T); also elsewhere on the board
DDR4_DQS7_N: IC17.A7 (UDQS_C); also elsewhere on the board
DDR4_DQS7_P: IC17.B7 (UDQS_T); also elsewhere on the board
DDR4_ODT0: IC16.K3 (ODT), IC17.K3 (ODT); also elsewhere on the board
DDR4_PAR: IC16.T3 (PAR), IC17.T3 (PAR); also elsewhere on the board
DDR4_RESET_N: IC16.P1 (RESET_N), IC17.P1 (RESET_N); also elsewhere on the board
DDR4_TEN_2: IC16.N9 (TEN), R142.1
DDR4_TEN_3: IC17.N9 (TEN), R144.1
DDR4_ZQ_2: IC16.F9 (ZQ), R141.2
DDR4_ZQ_3: IC17.F9 (ZQ), R143.2
GND: C229.2, C230.2, C231.2, C232.2, C233.2, C234.2, C235.2, C236.2, C237.2, C238.2, C239.2, C240.2, C241.2, C242.2, C243.2, C244.2, C245.2, C246.2, C247.2, C248.2, C249.2, C250.2, C251.2, C252.2, C253.2, C254.2, C468.2, C470.2, C472.2, C474.2, C475.2, C476.2, C477.2, C478.2, C479.2, C480.2, C481.2, C482.2, IC16.A2 (VSSQ_1), IC16.A8 (VSSQ_2), IC16.B2 (VSS_1), IC16.C9 (VSSQ_3), IC16.D2 (VSSQ_4), IC16.D8 (VSSQ_5), IC16.E1 (VSS_2), IC16.E3 (VSSQ_6), IC16.E8 (VSSQ_7), IC16.E9 (VSS_3), IC16.F1 (VSSQ_8), IC16.G8 (VSS_4), IC16.H1 (VSSQ_9), IC16.H9 (VSSQ_10), IC16.K1 (VSS_5), IC16.K9 (VSS_6), IC16.M9 (VSS_7), IC16.N1 (VSS_8), IC16.T1 (VSS_9), IC17.A2 (VSSQ_1), IC17.A8 (VSSQ_2), IC17.B2 (VSS_1), IC17.C9 (VSSQ_3), IC17.D2 (VSSQ_4), IC17.D8 (VSSQ_5), IC17.E1 (VSS_2), IC17.E3 (VSSQ_6), IC17.E8 (VSSQ_7), IC17.E9 (VSS_3), IC17.F1 (VSSQ_8), IC17.G8 (VSS_4), IC17.H1 (VSSQ_9), IC17.H9 (VSSQ_10), IC17.K1 (VSS_5), IC17.K9 (VSS_6), IC17.M9 (VSS_7), IC17.N1 (VSS_8), IC17.T1 (VSS_9), R141.1, R142.2, R143.1, R144.2; also elsewhere on the board
PSDDR: C229.1, C230.1, C232.1, C233.1, C235.1, C236.1, C238.1, C239.1, C241.1, C242.1, C244.1, C245.1, C247.1, C248.1, C250.1, C251.1, C253.1, C254.1, C468.1, C470.1, C474.1, C475.1, C476.1, C477.1, C479.1, C480.1, C481.1, C482.1, IC16.A1 (VDDQ_1), IC16.A9 (VDDQ_2), IC16.B3 (VDD_1), IC16.B9 (VDD_2), IC16.C1 (VDDQ_3), IC16.D1 (VDD_3), IC16.D9 (VDDQ_4), IC16.F2 (VDDQ_5), IC16.F8 (VDDQ_6), IC16.G1 (VDDQ_7), IC16.G7 (VDD_6), IC16.G9 (VDDQ_8), IC16.J1 (VDD_4), IC16.J2 (VDDQ_9), IC16.J8 (VDDQ_10), IC16.J9 (VDD_5), IC16.L1 (VDD_10), IC16.L9 (VDD_7), IC16.R1 (VDD_8), IC16.T9 (VDD_9), IC17.A1 (VDDQ_1), IC17.A9 (VDDQ_2), IC17.B3 (VDD_1), IC17.B9 (VDD_2), IC17.C1 (VDDQ_3), IC17.D1 (VDD_3), IC17.D9 (VDDQ_4), IC17.F2 (VDDQ_5), IC17.F8 (VDDQ_6), IC17.G1 (VDDQ_7), IC17.G7 (VDD_6), IC17.G9 (VDDQ_8), IC17.J1 (VDD_4), IC17.J2 (VDDQ_9), IC17.J8 (VDDQ_10), IC17.J9 (VDD_5), IC17.L1 (VDD_10), IC17.L9 (VDD_7), IC17.R1 (VDD_8), IC17.T9 (VDD_9); also elsewhere on the board
VPP: C231.1, C234.1, C237.1, C240.1, C243.1, C246.1, C472.1, C478.1, IC16.B1 (VPP_1), IC16.R9 (VPP_2), IC17.B1 (VPP_1), IC17.R9 (VPP_2); also elsewhere on the board
VTTREF: C249.1, C252.1, IC16.M1 (VREFCA), IC17.M1 (VREFCA); also elsewhere on the board

Notes on the sheet:
1010xx
jcc5
dcs7
DDR4 MEMORY 3
DDR4 MEMORY 4
1.2V
2.5V
0.6V
BASIC/design/hw_DAA.sch
hw_DAA/BASIC

Notices in the files:
parts and their libraries:
COPYRIGHT: Copyright (C) 2023 Ultra Librarian. All rights reserved.
